#include "bc7215_ac_lib.h"
#include <string.h>
#define jxusjozdkpwz  0
#define rqfnuxkfmrjn   1
#define erzjcdfgghiz 25
struct gpbqxitaiizd;
struct fcnkovzmnnhc;
struct hydvnyvlqvbd;
struct zecqpcygsbxm;
struct rbpeihvtnuyd;
union extraValue_t;
static void ymhmoqgzdhxz(const struct hydvnyvlqvbd* dfmcnuofogss);
static void tmvqpybvzasi(const struct gpbqxitaiizd* hxzmznxdkbkc);
static void zstezjgodril(const struct gpbqxitaiizd* hxzmznxdkbkc);
static void tkkyhdxekifj(uint8_t axlnvuvqassa[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* vpxwfpopdveh, const struct gpbqxitaiizd* hxzmznxdkbkc);
static void yxbwbukfxifv(const struct gpbqxitaiizd* hxzmznxdkbkc);
static uint8_t fsdssprrrxul(uint8_t byte);
static void uiumsbpihqax(const struct gpbqxitaiizd* hxzmznxdkbkc, bc7215DataVarPkt_t* vpxwfpopdveh);
static bc7215DataMaxPkt_t	prldlpdyrzae;
static bc7215DataMaxPkt_t	bymymfzfytqi;
static bc7215DataMaxPkt_t	ywvlglmedvkw;
static bc7215DataMaxPkt_t	hbrgftpnwiaa;
static bc7215DataMaxPkt_t	jqyeyoxnkgrm;
static bc7215FormatPkt_t	qjvstfqhzogz;
static bc7215FormatPkt_t   frqztynarjsr;
static bc7215FormatPkt_t   vsauocaxckoy;
static bc7215FormatPkt_t	zjnjccznsglv;
static uint8_t qaecoxiakqno[4][BC7215_MAX_RX_DATA_SIZE];
static uint8_t tlcqethmndyr[4][BC7215_MAX_RX_DATA_SIZE];
static int16_t hojowlpholah = -1;
static uint8_t vdkwwpizmwiw;
static uint8_t bqmuktkksqrn;
static uint8_t yfggcarljari;
static struct hydvnyvlqvbd* dutkzlcvtldb;
static uint8_t smxsfqhkzdsx[4];
static int8_t aptgxbmrneqq[4];
static bc7215CombinedMsg_t pmztwdjerbgj = {0,{.msg={.fmt=NULL, .datPkt=NULL}}};
static const struct gpbqxitaiizd* jxdluxfodxlj;
static bool altProtocolUsing;
static bool formatLoaded;
static bool secFmtLoaded;
static bool fahrenheitInit = false;
int msg, pnum;
static const uint8_t zbhuqvjsrngn[8] = { 0xff, 0x01, 0x03, 0x07, 0x0f, 0x1f, 0x3f, 0x7f };
static const uint8_t bsnougcexahd[8] = { 0xff, 0x80, 0xc0, 0xe0, 0xf0, 0xf8, 0xfc, 0xfe };
static const uint8_t picxegsrhkul[4] = { 0x03, 0x0c, 0x30, 0xc0 };
static const uint8_t jzcdxmdrohri[8] = { 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80 };
static const uint8_t gdqhvoumubms[16] = { 0x00, 0x02, 0x01, 0x03, 0x08, 0x0a, 0x09, 0x0b, 0x04, 0x06, 0x05, 0x07, 0x0c, 0x0e, 0x0d, 0x0f };
static const uint8_t iwrivqhbkfvb[16] = { 0, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f };
static const uint8_t qqiroospvssf[16] = { 0, 0x01, 0x01, 0x02, 0x01, 0x02, 0x02, 0x03, 0x01, 0x02, 0x02, 0x03, 0x02, 0x03, 0x03, 0x04 };
typedef struct zecqpcygsbxm { uint8_t		lwvakrvplqdt;
uint8_t		ecxwwscrklsl;
uint8_t		cglziorkljus;
uint8_t		agxxkyjkfjvo;
const uint8_t*	npuwofjjnfva;
} zecqpcygsbxm;
typedef struct rbpeihvtnuyd { uint8_t     pmnvkelkphhj;
uint8_t     lwvakrvplqdt;
uint8_t     ecxwwscrklsl;
uint8_t     cglziorkljus;
const uint8_t*    kgwutrfbqzlk;
} rbpeihvtnuyd;
typedef union extraValue_t { struct { uint8_t		gvceqldfsjbh;
uint8_t		svwxyronflvt;
uint8_t		hplcrxatdrct;
uint8_t		lhgglrlmdmxw;
uint8_t		lixjnvkxpnfb;
uint8_t		uifcjtjakghm;
const rbpeihvtnuyd*  rtwwplmlhifa;
} set;
struct { uint8_t		iwkglcyebvej;
uint8_t		zhembtdphtjh;
uint8_t		dwioqemcrosv;
uint8_t		cvpavisjxeyh;
} aevxhrsgdbyw;
} extraValue_t;
struct rsvujpsrigrz { const rbpeihvtnuyd*		yzanflvvuasy;
const struct gpbqxitaiizd*	hxzmznxdkbkc;
uint8_t 	umbdaltpywvp;
uint8_t		nuqhgngzwici;
};
struct muedplmamryr { struct { uint8_t	   srnwqkyvmfzi : 4;
uint8_t		uzeqpjupwhmw : 4;
} axlnvuvqassa;
uint8_t 	ecxwwscrklsl;
uint8_t		bits;
};
typedef void (*setExtBase_t)(const bc7215DataVarPkt_t* , const bc7215FormatPkt_t*);
union offBits_t { struct { struct muedplmamryr  lnrpcoyamxnd;
struct muedplmamryr  aqpwroyoznxu;
} gecmoisvuikh;
const bc7215DataVarPkt_t* lztusevbiwbk;
const bc7215CombinedMsg_t*      keirotrvlikq;
const setExtBase_t		cikjcvnkgdnt;
};
struct hydvnyvlqvbd { uint8_t		rrpbvlfhqqqb;
uint8_t		yvofwnzsaryf;
int8_t		subgyfrmfvfm;
uint8_t		atluxnsocctu;
struct { uint8_t		uzeqpjupwhmw : 5;
uint8_t    eowetqdkayvr : 1;
uint8_t		byte : 1;
uint8_t     vzxxvmdqqvsu  : 1;
} uzeqpjupwhmw;
int8_t		tqyuoskiftop;
int8_t		vzqhvprlrfjk;
uint8_t		xlnypmionbox;
uint8_t		gnxqscpvlkfw;
};
typedef bool (*algorithm_t)(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu);
struct fcnkovzmnnhc { algorithm_t kggtrdhlamff;
const struct hydvnyvlqvbd* dfmcnuofogss;
};
struct lmbejlluhdlz { const int8_t*	nrzmlxiqnvjp;
zecqpcygsbxm			kmdfjjawpchr;
};
struct gpbqxitaiizd { struct { uint8_t eyfkypwirzrg  : 1;
uint8_t yybieytaxyew : 1;
uint8_t    wibvdpdgotxx : 1;
uint8_t      tvmjtomrdnhm : 1;
uint8_t  hwzszqauakcw : 1;
uint8_t jooqmrimufrf : 1;
uint8_t  ztbdlqclufjr : 1;
} spec;
uint8_t  signature;
uint16_t bitLen;
uint16_t aevxhrsgdbyw[4];
zecqpcygsbxm  mmzlyxxngkvo;
zecqpcygsbxm  kgcvzngryhap;
zecqpcygsbxm  symhfchmtzss;
zecqpcygsbxm  qyillnqmaztz;
const extraValue_t*  dhpgcjvwtiqx;
union offBits_t	qinxsyloyejd;
const struct fcnkovzmnnhc* qfzhqhdtlzxl;
const struct lmbejlluhdlz*	dbooiubuftmj;
};
struct ojyxxaaevkqk { struct gpbqxitaiizd	hxzmznxdkbkc;
const void* 				yzanflvvuasy;
};
static uint8_t fsdssprrrxul(uint8_t byte);
static void oyvkixyldkse(const struct gpbqxitaiizd* hxzmznxdkbkc);
static bool vuawcztbcsbf(const struct gpbqxitaiizd* hxzmznxdkbkc);
static uint8_t lcedavuxmvyv(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso+wydcoduefbcj;
} static uint8_t ohqwopgkswdo(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso^wydcoduefbcj;
} static uint8_t kccvgegnwbsa(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso&wydcoduefbcj;
} static uint8_t fjhfjzoomfzf(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso|wydcoduefbcj;
} static uint8_t jhllapcyzkcr(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return wydcoduefbcj<<qmwmhvxiewso;
} static uint8_t dabhxuljoive(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return wydcoduefbcj>>qmwmhvxiewso;
} static uint8_t gvhcsyezglis(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso-wydcoduefbcj;
} static uint8_t uitjqqroyjwd(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { uint8_t kocjyhdltede = ((wydcoduefbcj&0x0f)+(wydcoduefbcj>>4))&0x0f;
if (kocjyhdltede & 0x08) { kocjyhdltede |= 0xf0;
} return qmwmhvxiewso+kocjyhdltede;
} static uint8_t tadgtzxwyvhp(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { (void)qmwmhvxiewso;
return wydcoduefbcj;
} static uint8_t yoafehiccmdt(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso&(~wydcoduefbcj);
} static uint8_t eoiuhvnzcyxh (uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return ((qmwmhvxiewso&0xf0)+(wydcoduefbcj&0xf0)) | ((qmwmhvxiewso+wydcoduefbcj)&0x0f);
} static uint8_t njfshrxuuqca(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso+fsdssprrrxul(wydcoduefbcj);
} static uint8_t fgngjafibtvm(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso-fsdssprrrxul(wydcoduefbcj);
} static uint8_t mzfrvyvseboo(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { return qmwmhvxiewso+qqiroospvssf[wydcoduefbcj>>4]+qqiroospvssf[wydcoduefbcj&0x0f];
} static uint8_t mruexciixdij(uint8_t qmwmhvxiewso, uint8_t wydcoduefbcj) { (void)wydcoduefbcj;
return ~qmwmhvxiewso;
} typedef uint8_t (*calFunc_t)(uint8_t, uint8_t);
static const calFunc_t ytomqlzpvxsh[] = { lcedavuxmvyv, ohqwopgkswdo, kccvgegnwbsa, fjhfjzoomfzf, jhllapcyzkcr, dabhxuljoive, gvhcsyezglis, uitjqqroyjwd, tadgtzxwyvhp, yoafehiccmdt, eoiuhvnzcyxh, njfshrxuuqca, fgngjafibtvm, mzfrvyvseboo, mruexciixdij };
static uint8_t aplnkhmzagcm(uint8_t axlnvuvqassa, uint8_t ecxwwscrklsl) { if (ecxwwscrklsl&0x01) { return qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0x0f;
} else { return qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]>>4;
} } static void nqiiygnhgjww(uint8_t axlnvuvqassa, uint8_t ecxwwscrklsl, uint8_t data) { data &= 0x0f;
if (ecxwwscrklsl&0x01) { qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2] = (qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0xf0)|data;
} else { qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2] = (qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0x0f) | (data<<4);
} } static uint8_t nyuienlkgotx(uint8_t axlnvuvqassa, uint8_t ecxwwscrklsl) { if (ecxwwscrklsl&0x01) { return qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]>>4;
} else { return qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0x0f;
} } static void qqezpqypkwmh(uint8_t axlnvuvqassa, uint8_t ecxwwscrklsl, uint8_t data) { data &= 0x0f;
if (ecxwwscrklsl&0x01) { qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2] = (qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0x0f) | (data<<4);
} else { qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2] = (qaecoxiakqno[axlnvuvqassa][ecxwwscrklsl/2]&0xf0)|data;
} } static bool gwwrdzbufaji(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { uint8_t axlnvuvqassa, wxrppogmmpte, edxwkqetbbwb, nibStart, nibEnd;
uint8_t ntylrpbzdrae;
uint8_t qmwmhvxiewso, wydcoduefbcj;
uint8_t rziichzxxsgx;
uint8_t tqyuoskiftop, targetPos;
wxrppogmmpte = dfmcnuofogss->rrpbvlfhqqqb>>4;
edxwkqetbbwb = dfmcnuofogss->rrpbvlfhqqqb&0x0f;
tqyuoskiftop = dfmcnuofogss->tqyuoskiftop&0x03;
axlnvuvqassa = wxrppogmmpte;
if (dfmcnuofogss->uzeqpjupwhmw.eowetqdkayvr) { rziichzxxsgx = yfggcarljari;
} else { rziichzxxsgx = 0;
} while (axlnvuvqassa <= edxwkqetbbwb) { if (axlnvuvqassa == wxrppogmmpte) { nibStart = dfmcnuofogss->yvofwnzsaryf;
} else { nibStart = 0;
} if (axlnvuvqassa == edxwkqetbbwb) { nibEnd = ((hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8)*2-1+dfmcnuofogss->subgyfrmfvfm;
} else { nibEnd = ((hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8)*2-1;
} for (ntylrpbzdrae=nibStart; ntylrpbzdrae<=nibEnd; ntylrpbzdrae=ntylrpbzdrae+dfmcnuofogss->atluxnsocctu) {
wydcoduefbcj = aplnkhmzagcm(axlnvuvqassa, ntylrpbzdrae);
if (dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
targetPos = ntylrpbzdrae+dfmcnuofogss->vzqhvprlrfjk;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
rziichzxxsgx &= dfmcnuofogss->xlnypmionbox;
if (dfmcnuofogss->tqyuoskiftop >= 0) { if (bnvuxeuihuzu) { rziichzxxsgx = (aplnkhmzagcm(tqyuoskiftop, targetPos)&(~dfmcnuofogss->xlnypmionbox)) | rziichzxxsgx;
nqiiygnhgjww(tqyuoskiftop, targetPos, rziichzxxsgx);
} else { if ((rziichzxxsgx&0x0f) != (aplnkhmzagcm(tqyuoskiftop, targetPos)&(dfmcnuofogss->xlnypmionbox))) { return false;
} } } } else { qmwmhvxiewso = rziichzxxsgx;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
} } axlnvuvqassa++;
} if (!dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { wydcoduefbcj = rziichzxxsgx;
qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->xlnypmionbox](qmwmhvxiewso,wydcoduefbcj);
yfggcarljari = rziichzxxsgx;
if (dfmcnuofogss->tqyuoskiftop >= 0) { if (dfmcnuofogss->uzeqpjupwhmw.byte) { targetPos = (hxzmznxdkbkc->aevxhrsgdbyw[tqyuoskiftop]+7)/8-1+dfmcnuofogss->vzqhvprlrfjk;
if (bnvuxeuihuzu) { qaecoxiakqno[tqyuoskiftop][targetPos] = rziichzxxsgx;
} else { return rziichzxxsgx == qaecoxiakqno[tqyuoskiftop][targetPos];
} } else { targetPos = (hxzmznxdkbkc->aevxhrsgdbyw[tqyuoskiftop]+7)/8*2-1+dfmcnuofogss->vzqhvprlrfjk;
if (bnvuxeuihuzu) { nqiiygnhgjww(tqyuoskiftop, targetPos, rziichzxxsgx&0x0f);
} else { return (rziichzxxsgx&0x0f) == aplnkhmzagcm(tqyuoskiftop, targetPos);
} } } } return true;
} static bool diwayqtuqhlk(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { uint8_t axlnvuvqassa, wxrppogmmpte, edxwkqetbbwb, nibStart, nibEnd;
uint8_t ntylrpbzdrae;
uint8_t qmwmhvxiewso, wydcoduefbcj;
uint8_t rziichzxxsgx;
uint8_t tqyuoskiftop, targetPos;
wxrppogmmpte = dfmcnuofogss->rrpbvlfhqqqb>>4;
edxwkqetbbwb = dfmcnuofogss->rrpbvlfhqqqb&0x0f;
tqyuoskiftop = dfmcnuofogss->tqyuoskiftop&0x03;
axlnvuvqassa = wxrppogmmpte;
if (dfmcnuofogss->uzeqpjupwhmw.eowetqdkayvr) { rziichzxxsgx = yfggcarljari;
} else { rziichzxxsgx = 0;
} while (axlnvuvqassa <= edxwkqetbbwb) { if (axlnvuvqassa == wxrppogmmpte) { nibStart = dfmcnuofogss->yvofwnzsaryf;
} else { nibStart = 0;
} if (axlnvuvqassa == edxwkqetbbwb) { nibEnd = ((hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8)*2-1+dfmcnuofogss->subgyfrmfvfm;
} else { nibEnd = ((hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8)*2-1;
} for (ntylrpbzdrae=nibStart; ntylrpbzdrae<=nibEnd; ntylrpbzdrae=ntylrpbzdrae+dfmcnuofogss->atluxnsocctu) {
wydcoduefbcj = nyuienlkgotx(axlnvuvqassa, ntylrpbzdrae);
if (dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
targetPos = ntylrpbzdrae+dfmcnuofogss->vzqhvprlrfjk;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
rziichzxxsgx &= dfmcnuofogss->xlnypmionbox;
if (dfmcnuofogss->tqyuoskiftop >= 0) { if (bnvuxeuihuzu) { rziichzxxsgx = (nyuienlkgotx(tqyuoskiftop, targetPos)&(~dfmcnuofogss->xlnypmionbox)) | rziichzxxsgx;
qqezpqypkwmh(tqyuoskiftop, targetPos, rziichzxxsgx);
} else { if (rziichzxxsgx != (nyuienlkgotx(tqyuoskiftop, targetPos)&(dfmcnuofogss->xlnypmionbox))) { return false;
} } } } else { qmwmhvxiewso = rziichzxxsgx;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
} } axlnvuvqassa++;
} if (!dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { wydcoduefbcj = rziichzxxsgx;
qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->xlnypmionbox](qmwmhvxiewso,wydcoduefbcj);
yfggcarljari = rziichzxxsgx;
if (dfmcnuofogss->tqyuoskiftop >= 0) { if (dfmcnuofogss->uzeqpjupwhmw.byte) { targetPos = (hxzmznxdkbkc->aevxhrsgdbyw[tqyuoskiftop]+7)/8-1+dfmcnuofogss->vzqhvprlrfjk;
if (bnvuxeuihuzu) { qaecoxiakqno[tqyuoskiftop][targetPos] = rziichzxxsgx;
} else { return rziichzxxsgx == qaecoxiakqno[tqyuoskiftop][targetPos];
} } else { targetPos = (hxzmznxdkbkc->aevxhrsgdbyw[tqyuoskiftop]+7)/8*2-1+dfmcnuofogss->vzqhvprlrfjk;
if (bnvuxeuihuzu) { qqezpqypkwmh(tqyuoskiftop, targetPos, rziichzxxsgx&0x0f);
} else { return (rziichzxxsgx&0x0f) == nyuienlkgotx(tqyuoskiftop, targetPos);
} } } } return true;
} static bool bcoifiiosqkn(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { uint8_t axlnvuvqassa, wxrppogmmpte, edxwkqetbbwb, byteStart, byteEnd;
uint8_t ntylrpbzdrae;
uint8_t qmwmhvxiewso, wydcoduefbcj;
uint8_t rziichzxxsgx;
uint8_t tqyuoskiftop, targetPos;
wxrppogmmpte = dfmcnuofogss->rrpbvlfhqqqb>>4;
edxwkqetbbwb = dfmcnuofogss->rrpbvlfhqqqb&0x0f;
tqyuoskiftop = dfmcnuofogss->tqyuoskiftop&0x03;
axlnvuvqassa = wxrppogmmpte;
if (dfmcnuofogss->uzeqpjupwhmw.eowetqdkayvr) { rziichzxxsgx = yfggcarljari;
} else { rziichzxxsgx = 0;
} while (axlnvuvqassa <= edxwkqetbbwb) { if (axlnvuvqassa == wxrppogmmpte) { byteStart = dfmcnuofogss->yvofwnzsaryf;
} else { byteStart = 0;
} if (axlnvuvqassa == edxwkqetbbwb) { byteEnd = (hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8-1+dfmcnuofogss->subgyfrmfvfm;
} else { byteEnd = (hxzmznxdkbkc->aevxhrsgdbyw[axlnvuvqassa]+7)/8-1;
} for (ntylrpbzdrae=byteStart; ntylrpbzdrae<=byteEnd; ntylrpbzdrae=ntylrpbzdrae+dfmcnuofogss->atluxnsocctu) {
wydcoduefbcj = qaecoxiakqno[axlnvuvqassa][ntylrpbzdrae];
if (dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
targetPos = ntylrpbzdrae+dfmcnuofogss->vzqhvprlrfjk;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
rziichzxxsgx &= dfmcnuofogss->xlnypmionbox;
if (dfmcnuofogss->tqyuoskiftop >= 0) { if (bnvuxeuihuzu) { rziichzxxsgx = (qaecoxiakqno[tqyuoskiftop][targetPos]&(~dfmcnuofogss->xlnypmionbox)) | rziichzxxsgx;
qaecoxiakqno[tqyuoskiftop][targetPos] = rziichzxxsgx;
} else { if (rziichzxxsgx != (qaecoxiakqno[tqyuoskiftop][targetPos]&(dfmcnuofogss->xlnypmionbox))) { return false;
} } } } else { qmwmhvxiewso = rziichzxxsgx;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](qmwmhvxiewso, wydcoduefbcj);
} } axlnvuvqassa++;
} if (!dfmcnuofogss->uzeqpjupwhmw.vzxxvmdqqvsu) { wydcoduefbcj = rziichzxxsgx;
qmwmhvxiewso = dfmcnuofogss->gnxqscpvlkfw;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->xlnypmionbox](qmwmhvxiewso,wydcoduefbcj);
yfggcarljari = rziichzxxsgx;
if (dfmcnuofogss->tqyuoskiftop >= 0) { targetPos = (hxzmznxdkbkc->aevxhrsgdbyw[tqyuoskiftop]+7)/8-1+dfmcnuofogss->vzqhvprlrfjk;
if (bnvuxeuihuzu) { qaecoxiakqno[tqyuoskiftop][targetPos] = rziichzxxsgx;
} else { return rziichzxxsgx == qaecoxiakqno[tqyuoskiftop][targetPos];
} } } return true;
} static bool rtvwetswdyac(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { (void)hxzmznxdkbkc;
if (bnvuxeuihuzu) { ymhmoqgzdhxz(dfmcnuofogss);
} return true;
} static bool uwbzrprspcpi(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { bool rziichzxxsgx;
struct gpbqxitaiizd yjvxktwphnbw;
yjvxktwphnbw.spec = hxzmznxdkbkc->spec;
yjvxktwphnbw.signature = hxzmznxdkbkc->signature;
yjvxktwphnbw.bitLen = hxzmznxdkbkc->bitLen;
yjvxktwphnbw.aevxhrsgdbyw[0] = hxzmznxdkbkc->dhpgcjvwtiqx->aevxhrsgdbyw.iwkglcyebvej;
yjvxktwphnbw.aevxhrsgdbyw[1] = hxzmznxdkbkc->dhpgcjvwtiqx->aevxhrsgdbyw.zhembtdphtjh;
yjvxktwphnbw.aevxhrsgdbyw[2] = hxzmznxdkbkc->dhpgcjvwtiqx->aevxhrsgdbyw.dwioqemcrosv;
yjvxktwphnbw.aevxhrsgdbyw[3] = hxzmznxdkbkc->dhpgcjvwtiqx->aevxhrsgdbyw.cvpavisjxeyh;
zstezjgodril(hxzmznxdkbkc);
tmvqpybvzasi(hxzmznxdkbkc);
uiumsbpihqax(&yjvxktwphnbw, (bc7215DataVarPkt_t*)&ywvlglmedvkw);
rziichzxxsgx = bcoifiiosqkn(&yjvxktwphnbw, dfmcnuofogss, bnvuxeuihuzu);
zstezjgodril(&yjvxktwphnbw);
tmvqpybvzasi(&yjvxktwphnbw);
uiumsbpihqax(hxzmznxdkbkc, (bc7215DataVarPkt_t*)&ywvlglmedvkw);
return rziichzxxsgx;
} static bool frfdpomjrbop(const struct gpbqxitaiizd* hxzmznxdkbkc, const struct hydvnyvlqvbd* dfmcnuofogss, bool bnvuxeuihuzu) { uint8_t ntylrpbzdrae;
(void)bnvuxeuihuzu;
for (ntylrpbzdrae=0; ntylrpbzdrae<dfmcnuofogss->subgyfrmfvfm; ntylrpbzdrae++)
{ if (qaecoxiakqno[dfmcnuofogss->rrpbvlfhqqqb][dfmcnuofogss->yvofwnzsaryf+ntylrpbzdrae] != *(hxzmznxdkbkc->symhfchmtzss.npuwofjjnfva+ntylrpbzdrae)) { return false;
} } return true;
} static void rejsmncfbtyb(const bc7215DataVarPkt_t* uhwwwuwzywjf, const bc7215FormatPkt_t* ecwdhtsbsjvk) { (void)uhwwwuwzywjf;
(void)ecwdhtsbsjvk;
hbrgftpnwiaa = prldlpdyrzae;
hbrgftpnwiaa.bitLen = ((const struct ojyxxaaevkqk*)jxdluxfodxlj->kgcvzngryhap.npuwofjjnfva)->hxzmznxdkbkc.bitLen;
bqmuktkksqrn = vdkwwpizmwiw;
frqztynarjsr = qjvstfqhzogz;
hbrgftpnwiaa.data[19] = 0x01;
hbrgftpnwiaa.data[7] = (hbrgftpnwiaa.data[7]&0xf0)|0x05;
} static const char*	VERSION = "V7.0 build 2614";
static const uint8_t cmntsrwmylfh[] =  {0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f};
static const uint8_t ytbrcludyvxf[] =  {0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x00};
static const uint8_t ypgweitsalat[] =  {0x16, 0x17, 0x18, 0x19, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x30};
static const uint8_t uwhhynzlqhub[] =  {0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d};
static const uint8_t tzobemjbbfwa[] =  {0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a};
static const uint8_t skkuscfhnkez[] =  {0x0f, 0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01};
static const uint8_t cfszeinxwraw[] =  {0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09};
static const uint8_t tlilvvzkpkzg[] =  {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t gcajumhjzbzp[] =  {0x00, 0x00, 0x08, 0x0c, 0x04, 0x06, 0x0e, 0x0a, 0x02, 0x03, 0x0b, 0x09, 0x01, 0x05, 0x0d, 0x07};
static const uint8_t ontgfftakrct[] = {0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02};
static const uint8_t tsdmfgpfasfa[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00};
static const uint8_t tjjeosglowtn[] = {0x61, 0x71, 0x81, 0x91, 0x02, 0x12, 0x22, 0x32, 0x42, 0x52, 0x62, 0x72, 0x82, 0x92, 0x03};
static const uint8_t cjspeajeetae[] = {0x00, 0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x09, 0x08, 0x0a, 0x0b, 0x0e};
static const uint8_t quywhrfyrrqx[] = {0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e};
static const uint8_t kcaqxotfygwa[] = {0x19, 0x18, 0x17, 0x16, 0x15, 0x14, 0x13, 0x12, 0x11, 0x10, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B};
static const uint8_t zbyuugoskdnw[] = {0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b};
static const uint8_t furrpwcvfmwl[] = {0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const uint8_t amamuejctadz[] = {0x00, 0x0a, 0x14, 0x1e, 0x28, 0x32, 0x3c, 0x46, 0x50, 0x5a, 0x64, 0x6e, 0x78, 0x82, 0x8c};
static const uint8_t lkcleczckmqs[] = {0x18, 0x1A, 0x1c, 0x1e, 0x20, 0x22, 0x24, 0x26, 0x28, 0x2a, 0x2c, 0x2e, 0x30, 0x32, 0x34};
static const uint8_t duwlxejfbcur[] = {0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x00};
static const uint8_t zkrqupjjpcjj[] = {0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27};
static const uint8_t vcslgboymbrm[] = {0x0e, 0x0d, 0x0c, 0x0b, 0x0a, 0x09, 0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00};
static const uint8_t pcarcrbepsfm[] = {0x08, 0x07, 0x06, 0x05, 0x04, 0x03, 0x02, 0x01, 0x00, 0x0F, 0x0E, 0x0D, 0x0C, 0x0B, 0x0A};
static const uint8_t rrdygacrtxau[] = {0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x00};
static const uint8_t sknaonxhcbby[] = {0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x60};
static const uint8_t pzskpnrdiidk[] = {0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x40};
static const uint8_t cxsrtekxdzqc[] = {0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24};
static const uint8_t tahpslefwigh[] = {0x0f, 0x1e, 0x2d, 0x3c, 0x4b, 0x5a, 0x69, 0x78, 0x87, 0x96, 0xa5, 0xb4, 0xc3, 0xd2, 0xe1};
static const uint8_t iflsbfgramhw[] = {0x00, 0x01, 0x03, 0x02, 0x06, 0x07, 0x05, 0x04, 0x0c, 0x0d, 0x0f, 0x0e, 0x0a, 0x0b, 0x09};
static const uint8_t ervibksmelem[] = {0x42, 0x44, 0x45, 0x47, 0x49, 0x4b, 0x4d, 0x4e, 0x50, 0x52, 0x54, 0x56, 0x57, 0x59, 0x5b};
static const uint8_t ashsyhfolavx[] = {0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x03, 0x0b, 0x07, 0x0f};
static const uint8_t ldcsxehevkyw[] = {0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20, 0x03, 0x00};
static const uint8_t kuyqbnkbyxpc[] = {0x07, 0x0b, 0x03, 0x0d, 0x05, 0x09, 0x01, 0x0e, 0x06, 0x0a, 0x02, 0x0c, 0x04, 0x08, 0x00};
static const uint8_t oqkgqijxnddh[] = {0x00, 0x0f, 0x07, 0x0b, 0x03, 0x0d, 0x05, 0x09, 0x01, 0x0e, 0x06, 0x0a, 0x02, 0x0c, 0x04};
static const uint8_t tpncdzkkpnwf[] = {0x08, 0x08, 0x08, 0x04, 0x0c, 0x02, 0x0a, 0x06, 0x0e, 0x01, 0x09, 0x05, 0x0d, 0x0d, 0x0d};
static const uint8_t xorskegihgke[] = {0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19};
static const uint8_t tibdbpfmxuaq[] = {0x30, 0x32, 0x34, 0x36, 0x38, 0x3A, 0x3C, 0x3E, 0x40, 0x42, 0x44, 0x46, 0x48, 0x4A, 0x4C, 0xC0};
static const uint8_t exlhnycqjhzi[] = {0x1d, 0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b};
static const uint8_t jiyzgwqhwaux[] = {0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10};
static const uint8_t plrjbdocqtqa[] = {0x1e, 0x1f, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c};
static const uint8_t drkbwjcqomkf[] = {0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x00, 0x01, 0x02, 0x03};
static const uint8_t idrqzusdprtf[] = {0x07, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04, 0x03, 0x07, 0x06, 0x05, 0x04};
static const uint8_t asiupcazjtid[] = {0x09, 0x09, 0x09, 0x09, 0x09, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x07, 0x07, 0x07};
static const uint8_t oqmqtbrtarwr[]  = {0,   1,   4,  2,  3};
static const uint8_t gujgntlkisyx[]  = {0,   1,   0,  2,  3};
static const uint8_t tghruybtsqpf[]  = {0,   1,   4,  2,  6};
static const uint8_t tafrsqjnefqd[]  = {0,   1,   8,  2,  4};
static const uint8_t lmlgvjpkpdnq[]  = {0,   1,   3,  2,  4};
static const uint8_t rqbgjoqmfipj[]  = {4,   2,   1,  3,  5};
static const uint8_t jnioisscmtak[]  = {8,   3,   1,  2,  7};
static const uint8_t ojeoftlzgpeq[]  = {1,   0,   3,  2,  2};
static const uint8_t oprimmhycskq[]  = {0,   3,   4,  2,  6};
static const uint8_t dflwnjfakmyn[] = {7,   0,   3,  1,  2};
static const uint8_t suqrsgzbyjrl[] = {4,   0,   3,  1,  2};
static const uint8_t wrrnxlvsulqv[] = {7,   5,   3,  6,  4};
static const uint8_t fsrpwjnnruda[] = {7,   6,   3,  5,  4};
static const uint8_t qwkmptnrpjag[] = {7,   6,   3, 0x0a,0x0b};
static const uint8_t pihojjvoszmj[] = {4,   0,   1,  2,  3};
static const uint8_t huqcmroqemjh[] = {0x13, 0x02, 0x01, 0x03, 0x13};
static const uint8_t kobtotblliyt[] = {8,   4,   8,  2,  1};
static const uint8_t xvlibyqkrdrf[] = {0,   2,   6,  4,  8};
static const uint8_t mzesnovedksd[] = {1,   2,   4,  0,  8};
static const uint8_t ayoirfczdouv[] = {0,   0,   2,  1,  5};
static const uint8_t amjlwwtuumqb[] = {6,   2,   4,  3,  0};
static const uint8_t buvyfaternak[] = {0,   2,   1,  3,  4};
static const uint8_t dvpuldozuwvu[] = {2,   0,   3,  1,  1};
static const uint8_t rtblkcmfhvfv[] = {8,   8, 0x0a, 0x0b,  9};
static const uint8_t csgmjvbkkwah[] = {5,   1,   2,  4,  3};
static const uint8_t svyugtaogvsg[] = {4,   0,   1,  2,  5};
static const uint8_t utmyxoywjjgs[] = {3,   1,   3,  2,  2};
static const uint8_t kdtknwphwltk[] = {0,   1,   2,  4,  3};
static const uint8_t llwlyvriyeuj[] = {0,   1,   2,  3,  4};
static const uint8_t zpdorivacyev[] = {1,   2,   1,  3,  5};
static const uint8_t zefptmbzmdcl[] = {0x42,  0x42, 0xc3,  0x42,  0xc3};
static const uint8_t ycdmpncfihnp[] = {0,   2,   4,  1,  3};
static const uint8_t rgwtgswgpuya[] = {0,   8,   4, 0x0c,  0x0c};
static const uint8_t acrfzoslpxvx[] = {2,   0,   4,   1,  3};
static const uint8_t gmsvovqvqsnb[] = {8,   4,   2,  1,  0};
static const uint8_t glchtfgsebbd[] = {1,   2,   0,  3,  4};
static const uint8_t xtoiikraetvd[] = {0x23, 5, 0x21,  7,  9};
static const uint8_t dmwkqflvmzup[] = {0x0B,  0x06, 0x08,  0x04,  0x02};
static const uint8_t qnmyddjmgedp[] = {2,   2,   1,  3,  0};
static const uint8_t jjkxidtpszvy[] = {2,   1,   1,  3,  0};
static const uint8_t hrxdawpyshai[] = {9,   9,   1,  5,  0x0d};
static const uint8_t qskjfhumgdxg[] = {9,   6,   1,  5,  0x0d};
static const uint8_t sktvbrbbkqlo[] = {6,   2,   1,  3,  0};
static const uint8_t iexxstwfurfd[] = {0,   3,   1,  2,  7};
static const uint8_t edxqfohleqap[] = {3,   1,   2,  5,  0};
static const uint8_t ppqwlkzsrggl[] = {2,   3,   1,  2,  2};
static const uint8_t rbqteagsldzp[] = {7,   7,   1,  5,  3};
static const uint8_t xmmbocarwnfb[] = {3,   2,   1,  7,  0};
static const uint8_t lgzqftmoksec[] = {0,   4,   2,  6,  0};
static const uint8_t vfrrxicjjbuw[] = {0,   4,   7,  2,  1};
static const uint8_t cuschsbgglyo[] = {0,   8,   1,  4,  2};
static const uint8_t bqvhwdgpcegx[] = {7,   6,   8,  4,  2};
static const uint8_t xrtmtnnigcml[] = {0,   2,   1,  4,  8};
static const uint8_t lnrhfixuybse[] = {0,   4,   3,  1,  2};
static const uint8_t kqmuudzshyev[] = {2,   4,   3,  5,  0x0c};
static const uint8_t vmmjkuxiguyg[] = {7,   3,   6,  9,  8};
static const uint8_t nhuuaeatpxut[] = {3,   0,   4,  1,  2};
static const uint8_t ybmndoxkcgvq[] = {7,   6,   4,  5,  3};
static const uint8_t jppjhqlrjxqz[] = {5,   2,   1,  3,  4};
static const uint8_t hhtcymniazqt[] = {1,   3,   4,  2,  6};
static const uint8_t gfyccfwkubos[] = {3,   2,   1,  7,  0};
static const uint8_t kuduzvpllyzr[] = {0x0a, 2,  8,  1,  4};
static const uint8_t gsgvhxtxcjom[] = {7,  4,  6,  4,  3};
static const uint8_t clxbgiliwlkd[] = {1,  6,  6,  5,  0x0a};
static const uint8_t qluwdrmtlnbc[] = {0,  0,  0,  4,  3};
static const uint8_t dbffjkhqcczz[] = {1,  1,  3,  2,  0};
static const uint8_t makhjmseykqq[] = {1,  6,  0x0d,  6,  0x0a};
static const uint8_t qaekeemfcech[] = {1,  2,  6,  3,  0};
static const uint8_t ozcvxzcbzysd[] = {4,  2,  6,  3,  5};
static const uint8_t ocakliobujtr[] = {1,  1,  1,  1,  1};
static const uint8_t egtqmfwlmndn[] = {0x23, 0x03, 0x03, 0x22, 0x21};
static const uint8_t cjwtggkjrket[] = {7,  3,  1,  2,  2};
static const uint8_t lbjnlnoqtjre[] = {0x05, 0x41, 0x24, 0x42, 0x03};
static const uint8_t dpassarelhfz[] = {0,  0,  1,  0,  2};
static const uint8_t zxtkmrtwpcwq[] = {0,  0,  2,  4,  6};
static const uint8_t xbhgwzixmpds[] = {4,  2,  0,  1,  3};
static const uint8_t asearepltykx[] = {5,  1,  3,  2,  4};
static const uint8_t dhyevkwmtrkz[] = {0,  0,  2,  6,  4};
static const uint8_t njxjmutvixzc[] = {1,  2,  4,  3,  5};
static const uint8_t srhimdmxtgvx[] = {1,  4,  2,  3,  5};
static const uint8_t vucznueqscto[] = {1,  2,  6,  4,  3};
static const uint8_t wvxudbqtvdqv[] = {4,  6,  0,  2,  3};
static const uint8_t bbmoirnyyvpa[] = {3,  2,  0,  1,  2};
static const uint8_t promikpkgqdf[] = {0,  8,  2,  4,  1};
static const uint8_t cugupfctjayw[] = {3,  2,  1,  0,  1};
static const uint8_t xgwistjfovfg[] = {0,  1,  2,  4,  8};
static const uint8_t krpfaigmnlww[] = {0,  2,  8,  4,  3};
static const uint8_t etiaceogyvvv[] = {0,  4,  0x0c,  8,  4};
static const uint8_t juzymymxyjcf[] = {3,  1,  2,  4,  5};
static const uint8_t rwdoaalpkfsr[] = {0,  2,  1,  2,  3};
static const uint8_t jmmwdmxpdceu[] = {3,  1,  0,  2,  4};
static const uint8_t oyapdunuwhxp[] = {2,  0,  3,  1,  4};
static const uint8_t jqhzoursarms[] = {7,  3,  6,  5,  1};
static const uint8_t myniptpptjsc[] = {0,  3,  1,  3,  4};
static const uint8_t mfggenbbsmvw[] = {0,  2,  3,  2,  4};
static const uint8_t aqppyhghhlof[] = {0x0c,  2,  1,  3,  4};
static const uint8_t xmpbznnszzgm[] = { 0,    1,     3,    5, 5};
static const uint8_t nvjodrzzlddk[] = { 0,    1,     2,    3, 3};
static const uint8_t ssgjvfhyuect[] = { 5,    3,     2,    1, 1};
static const uint8_t eerwapzvukix[] = { 0,    2,     3,    1, 1};
static const uint8_t kfiokuecrvod[] = { 0,    2,     3,    5, 5};
static const uint8_t wqremrbmlwyg[] = { 0,    2,     0,    4, 4};
static const uint8_t sndrvydgwxhi[] = { 5,    1,     2,    4,  0};
static const uint8_t cxneheyfiqpy[] = {0x0a,  3,     5,    7, 7};
static const uint8_t kuwjmesodnrm[] = { 0,    1,     2,    4};
static const uint8_t davjvkjsdpah[] ={ 7,    3,     2,    1, 1};
static const uint8_t zveummuuqpoh[] ={ 0,    3,     2,    1, 1};
static const uint8_t eqyztsfcxhky[] ={ 7,    5,     3,    1, 1};
static const uint8_t srmirchdvmvy[] ={ 7,    4,     5,    6, 6};
static const uint8_t hbkwawzvifnd[] ={ 3,    0,     1,    2, 5};
static const uint8_t fvnvesgvmmts[] ={0xFF, 0x20, 0x40, 0x60, 0x60};
static const uint8_t kgysironeztb[] ={ 7,    6,     5,    4, 4};
static const uint8_t zwozxthnnebr[] ={ 3,    4,     3,    2, 2};
static const uint8_t ypgaghxzmqrw[] ={ 8,    4,     2,    1, 0};
static const uint8_t pmgsyczkuvvk[] ={ 1,    4,     8,    2, 2};
static const uint8_t laidcvjzjwzt[] = { 6,    1,    3,    5,  5};
static const uint8_t wqcopogbpbpz[] = { 5,    4,     2,    1, 0};
static const uint8_t ujorjtjrsrec[] = { 4,    3,     2,    1, 1};
static const uint8_t tahcygxlrqmp[] = { 5,    7,     2,   1,  0};
static const uint8_t iudqvuwwzzfo[] = { 5,    1,     2,    3, 3};
static const uint8_t wzkubwkdaosj[] = { 4,    6,     5,    7, 4};
static const uint8_t kpjntihjrmdt[] = { 0,    3,     1,    2, 0};
static const uint8_t wrutisakyhxe[] = { 0x0a, 4,     6,    7};
static const uint8_t onpxavfvifmb[] = { 0,    8,   0x0c,   4,  2};
static const uint8_t evgslnjlbbxv[] = { 5,    0,     2,    4, 0};
static const uint8_t uyhcrzyfqrbd[] = {0xff, 0x8a, 0xad, 0xd0, 0xd0};
static const uint8_t kbeiscfdapob[] = {8, 1, 2, 4, 4};
static const uint8_t azexlyfhzmjp[] = {0x00, 0x0a, 0x32, 0x63, 0x63};
static const uint8_t uwfodcrrykio[] = {3, 2, 1, 0, 0};
static const uint8_t jjupysshyxnm[] = {7, 5, 4, 3, 3};
static const uint8_t ivclzcupstut[] = {4, 0, 2, 3};
static const uint8_t mwgxuyotwelz[] = {7, 1, 2, 3, 3};
static const uint8_t hiiobvtytlxu[] = {6, 0, 2, 4, 4};
static const uint8_t qrxesvjaizkd[] = {7, 5, 3, 2, 2};
static const uint8_t zqtslcvzjlbs[] = {0x0f, 2, 4, 6, 6};
static const uint8_t ixdmyrsxsnwd[] = {0, 4, 6, 2, 2};
static const uint8_t kqnqeirkhepj[] = {0, 2, 4, 5, 6};
static const uint8_t bptiyeqxsrnd[] = {0, 1, 6, 8, 8};
static const uint8_t rgospvmfksfb[] = {1, 2, 4, 8, 8};
static const uint8_t kgpncohttvpp[] = {5, 2, 3, 4, 4};
static const uint8_t qlyufofbkekd[] = {1, 2, 4, 5, 3};
static const uint8_t oxczxmxtlfvg[] = {5, 1, 3, 4, 4};
static const uint8_t zdoyojipkifw[] = {1, 8, 4, 2, 2};
static const uint8_t dgaywuihyxnp[] = {7, 2, 1, 0, 2};
static const uint8_t cfxbmslkginh[] = {4, 4, 5, 6, 6};
static const uint8_t fwzhjkcbkbzj[] = {4, 7, 6, 5};
static const uint8_t zwpdmgxmjngn[] = {0, 3, 7, 5};
static const uint8_t yvgjmdzgltwv[] = {0, 2, 6, 5};
static const uint8_t kqxvuienezqh[] = {0, 3, 4, 5};
static const uint8_t pozadfedxavz[] = {2, 3, 5, 7};
static const uint8_t lxfkqoyuzihi[] = {0, 2, 1, 3};
static const uint8_t vhmperrnwyuc[] = {1, 2, 3, 4};
static const uint8_t gmcoqyvowqls[] = {7, 1, 3, 5};
static const uint8_t wnncwqsqsynw[] = {4, 5, 6, 7};
static const uint8_t ympjwtujtzjj[] = {0, 2, 6, 1};
static const uint8_t fxrzumoltkin[] = {7, 4, 2, 1};
static const uint8_t zoftehwidnrp[] = {3, 1, 2, 0};
static const uint8_t pcqdqyashrim[] = {0, 2, 1, 8};
static const uint8_t ycawfkzekccz[] = {7, 6, 4, 3};
static const uint8_t jfmsxunfkwnt[] = {8, 2, 6, 4};
static const uint8_t gmuaoolsoaak[] = {6, 2, 3, 4, 1};
static const uint8_t txrpvrhoawwv[] = {4, 1, 2, 3};
static const uint8_t pholksftlwlf[] = {3, 3, 1, 0};
static const uint8_t haylvzeejxtf[]   = {0, 1, 6, 4,  5, 5};
static const uint8_t okxlgwwojlqc[]   = {3, 4, 1, 5,  0, 0};
static const uint8_t tgtfklffchvs[] = {0, 1, 3, 3, 0};
static const uint8_t giocrwpysbgq[]   = {3, 3, 0x0c, 3, 0x0b, 3};
static const uint8_t bhularavlxpf[] = {0x66, 0x28, 0x3c, 0x64, 0x65};
static const uint8_t ngyffxnglrbo[] = {0x66, 0x14, 0x3c, 0x64, 0x65};
static const uint8_t eckwleyifbuy[]   = {1, 1, 1, 2, 0x0f, 0x0f};
static const uint8_t opbubkswvgez[] = {1, 0, 0, 0, 0};
static const uint8_t iirqplykcsjl[]   = {1, 2, 4, 6, 3, 3};
static const uint8_t buwyjftobvfj[]   = {5, 7, 0x0b, 9, 0x0c, 0x0c};
static const uint8_t vqztcbnniyep[]   = {6, 7, 2, 3, 0, 1};
static const uint8_t vdllhntvjrzl[]   = {5, 4, 6, 2, 7, 7};
static const uint8_t cgirezmuuzsl[]  = {2, 2, 6, 0x11, 1, 1};
static const uint8_t szqejexuipzr[]  = {1, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t lrvtylfsvlro[]  = {9, 8, 4, 5, 1, 1};
static const uint8_t wxzfgfvwifep[]  = {1, 1, 0x0f, 2, 0x0f, 0x0f};
static const uint8_t rexdwghznmmj[] = {0x5d, 0x5d, 0x41, 0x5d, 0x5d};
static const uint8_t dskfsdqvpsfm[] = {1, 1, 0, 1, 1};
static const uint8_t ezzphgiiazhk[] = {0xb9, 0xb9, 0x82, 0xb9, 0xb9};
static const uint8_t uhabhvecnpgk[]  = {0x14, 0x10, 0x08, 0x0c, 0x0c};
static const uint8_t resqxheahzcf[] = {0x38, 0x38, 0x00, 0x38, 0x38};
static const uint8_t sftvyfwssldz[]  = {3, 4, 7, 6, 0, 0};
static const uint8_t iahlckzwlqlv[] = {6, 6, 0, 2, 0};
static const uint8_t uddchsavduck[] = {0, 0, 1, 1, 0};
static const uint8_t ogkmhkfakteu[]  = {0, 0, 1, 0, 0, 0};
static const uint8_t yoanurqmkmwa[]  = {0x44, 0x43, 0x13, 0x42, 0x13, 0x13};
static const uint8_t shlehzkvxzjx[]  = {8, 9, 7, 0x0c, 3, 3};
static const uint8_t eldhmgwhdxql[] = {0, 0, 0, 0, 0};
static const uint8_t gfrivhrrckkq[]  = {2, 3, 1, 5, 0, 0, 0x16};
static const uint8_t thwsnzxdiqor[]  = {9, 0x0a, 8, 0x0f, 0, 0};
static const uint8_t hzlfkoyghsgg[] = {1, 3, 0, 0, 1};
static const uint8_t imhhvyymfnup[] = {0x80, 0x14, 0x5a, 0x80};
static const uint8_t vmfvhyyvcdpo[]  = {2, 2, 6, 0x11, 0x25, 0x25};
static const uint8_t fhvyaphwmtmt[]  = {4, 4, 0, 5, 0, 0};
static const uint8_t sfogdqkjwmyz[] = {0x79, 0x79, 0x55, 0x79, 0x79};
static const uint8_t zcnokhwhweyw[] = {0x79, 0x79, 0x42, 0x79, 0x79};
static const uint8_t njkrlbejkiyx[]  = {0x0d, 0x0d, 0x09, 0x11, 0x06, 0X06};
static const uint8_t hghxsrwbzetq[]  = {1, 1, 1, 1, 0x0a, 6};
static const uint8_t xcjqyivqssjo[]  = {1, 1, 1, 1, 0x0a, 0x0a};
static const uint8_t agktjmrthdnf[] = {0xa7, 0xa7, 0x45, 0x95, 0xa7};
static const uint8_t itplntpkarzz[]  = {4, 4, 4, 4, 5, 5};
static const uint8_t hmzbnjtrewvr[]  = {0, 0, 0, 0, 1, 1};
static const uint8_t amqbadksuqji[]  = {3, 3, 3, 3, 2, 1};
static const uint8_t tamwmprilcmd[]  = {2, 2, 2, 2, 2, 1};
static const uint8_t nsqgxdctwjwr[]  = {0, 0, 0, 0, 2, 1};
static const uint8_t qmxxozupvoyv[] = {0, 0, 0, 1, 1};
static const uint8_t lwzdjhevyehp[] = {2, 0, 0, 0, 1};
static const uint8_t fdtplomslzix[] = {7, 0, 1, 2};
static const uint8_t trkkztrvkfxv[] = {1, 2, 2, 0, 2};
static const uint8_t bnzmvxodrorx[] = {7, 7, 7, 2, 6};
static const uint8_t wlstbotqbsyc[] = { 0x00, 0xc0, 0x80, 0x40, 0x00};
static const uint8_t rynryuzkhjgk[] = { 0x02, 0x02, 0x00, 0x02, 0x02};
static const uint8_t srzxfogymfvw[] = { 0x07, 0x07, 0x07, 0x05, 0x07};
static const uint8_t zabtvpebcgso[] = { 0x80, 0x00, 0x00, 0x00, 0x00};
static const rbpeihvtnuyd faryrwqvegui[] = { {2, 1, 2, 0xe0, wlstbotqbsyc}, {0, 0, 0, 0, NULL} };
static const rbpeihvtnuyd fyxckfrcbimd[] = { {2, 1, 2, 0xe0, wlstbotqbsyc}, {1, 1, 1, 0x03, rynryuzkhjgk}, {1, 0, 11, 0x07, srzxfogymfvw}, {1, 0, 12, 0x80, zabtvpebcgso}, {0, 0, 0, 0, NULL} };
static const uint8_t elpklnlylcgq[] = { 0, 0, 0, 0, 0x04, 0x04};
static const rbpeihvtnuyd gibhnwvjibkv[] = { {3, 1, 0, 0x04, elpklnlylcgq}, {0, 0, 0, 0, NULL} };
static const uint8_t aokogjstnsjr[] = { 0x00, 0x0, 0x10, 0x00, 0x00};
static const rbpeihvtnuyd aobcwiazgkkt[] = { {1, 0, 9, 0x10, aokogjstnsjr}, {0, 0, 0, 0, NULL} };
static const uint8_t qqrbbspzfmja[] = { 0x20, 0x0, 0x0, 0x00, 0x00};
static const rbpeihvtnuyd decolzmcqreo[] = { {3, 0, 10, 0x20, qqrbbspzfmja}, {0, 0, 0, 0, NULL} };
static const uint8_t eywwqodkzqjm[] = { 0x50, 0x50, 0x50, 0x00, 0x40};
static const rbpeihvtnuyd gxtkkxjobxml[] = { {1, 1, 5, 0x70, eywwqodkzqjm}, {0, 0, 0, 0, NULL} };
static const uint8_t cxxhlnxgqyfv[] = {0x02, 0x04, 0x06, 0x08, 0x0a, 0x0c, 0x0e, 0x10, 0x11, 0x13, 0x14, 0x16, 0x18, 0x1a, 0x1b};
static const rbpeihvtnuyd jmetxlpoaeek[] = { {0, 0, 3, 0xfF, cxxhlnxgqyfv}, {0, 0, 0, 0, NULL} };
static const uint8_t fzwdmjsbcrqs[] = { 0x09, 0x09, 0x02, 0x09, 0x09};
static const rbpeihvtnuyd odohypyaydjs[] = { {1, 1, 10, 0x0F, fzwdmjsbcrqs}, {0, 0, 0, 0, NULL} };
static const uint8_t hmioyfnrrikz[] = {0xc0, 0xc0, 0xc0, 0x00, 0xc0};
static const rbpeihvtnuyd ripziuuuphym[] = { {1, 0, 4, 0xC0, hmioyfnrrikz}, {3, 0, 10, 0x07, fhvyaphwmtmt}, {0, 0, 0, 0, NULL} };
static const uint8_t ohshgislclsn[] = {6, 6, 6, 6, 6};
static const uint8_t erfctbhnluae[] = {0, 2, 1, 0};
static const rbpeihvtnuyd ndnejedmebyw[] = { {1, 0, 4, 0x0f, ohshgislclsn}, {2, 0, 4, 0x03, erfctbhnluae}, {0, 0, 0, 0, NULL} };
static const uint8_t ehpcgvqiltky[] = {0, 0xc0, 0x80, 0x40};
static const rbpeihvtnuyd yefgpcnbeoqm[] = { {2, 1, 2, 0xE0, ehpcgvqiltky}, {0, 0, 0, 0, NULL} };
static const uint8_t lievpwlqhwsj[] = {0, 0x20, 0x60, 0xA0};
static const rbpeihvtnuyd exfyfjaljvjh[] = { {2, 0, 4, 0xE0, lievpwlqhwsj}, {0, 0, 0, 0, NULL} };
static const uint8_t fvqhcyqirzpt[] = {0, 0, 0, 0, 4};
static const rbpeihvtnuyd lwgmjdzuimtg[] = { {2, 0, 4, 0x04, fvqhcyqirzpt}, {0, 0, 0, 0, NULL} };
static const int8_t khavbnzeldsl[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t jhsulolqpzko[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t kwajdgzvnbjj[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t snzmmpcjdzjo[] = { 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t xnnowhszwjsj[] = { 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t ubhfwqahykef[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16};
static const int8_t oqbuigucoivc[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t boateqjhekfw[] = { 16-16, 16-16, 16-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16,  20-16, 21-16, 21-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t woarbopqeuss[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t rebnlonfabes[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t dxbkjwurnkbr[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const int8_t iebzljjbytvu[] = { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c};
static const int8_t pbmggltoeadc[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t gkjyomlkmapd[] = { 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t powivspfcatk[] = { 16-16, 16-16, 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16};
static const int8_t hrjqivghsgfj[] = { 16-10, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 24-16, 24-16, 24-16, 25-16, 25-16, 26-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t ojwvoytgirzo[] = { 16-16, 17-16, 17-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 27-16, 27-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16};
static const int8_t nyqpjbbxtmgf[] = { 16-16, 16-16, 16-16, 18-16, 18-16, 19-16, 19-16, 20-16, 20-16, 21-16, 21-16, 22-16, 22-16, 23-16, 23-16, 23-16, 24-16, 24-16, 25-16, 25-16, 26-16, 28-16, 28-16, 29-16, 29-16, 30-16, 30-16, 30-16, 30-16};
static const uint8_t ajvrfjpbcfpo[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t mtstslotpriy[] = { 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t lkbznxqiesiz[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t xrjajgppykcz[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t nopqffvtmuyp[] = { 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d};
static const uint8_t moawowkntgnf[] = { 0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88};
static const uint8_t zubvwxaeucxc[] = { 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t szssavgevhep[] = { 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f, 0x20};
static const uint8_t zwhtoeafiyoe[] = { 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0};
static const uint8_t yyhvlmpuooub[] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t btjhitcgorwo[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t zutwmokafppz[] = { 0x3D, 0x3D, 0x3E, 0x3F, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58};
static const uint8_t wyvotfszqwoi[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t xtnefcleezay[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1};
static const uint8_t bjtbyvcgrnyn[] = { 0X79, 0x7B, 0x7D, 0x7F, 0x81, 0x83, 0x85, 0x87, 0x89, 0x8B, 0x8D, 0x8F, 0x91, 0x93, 0x95, 0x97, 0x99, 0x9B, 0x9D, 0x9F, 0xA1, 0xA3, 0xA5, 0xA7, 0xA9, 0xAB, 0xAD, 0xAF, 0xB1};
static const uint8_t vivhnporwyvr[] = { 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1};
static const uint8_t tbvexvgfibqd[] = { 0x1c, 0x1d, 0x1e, 0x1f, 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18};
static const uint8_t zregqnqoosue[] = { 0x01, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x01, 0x06, 0x02, 0x07, 0x03, 0x08, 0x04, 0x00, 0x05, 0x05};
static const uint8_t stkftkqdgzbe[] = { 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1};
static const uint8_t azddxtjyeqae[] = { 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1};
static const uint8_t sctqntkdamav[] = { 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0, 0x0f, 0x0f};
static const struct lmbejlluhdlz iyuladpyuyeb = { khavbnzeldsl, { 0, 1, 0x40, 6, ajvrfjpbcfpo } };
static const struct lmbejlluhdlz fefkuoviwtks = { jhsulolqpzko, { 0, 3, 0x04, 2, mtstslotpriy } };
static const struct lmbejlluhdlz mvahknhdntlr = { xnnowhszwjsj, { 0, 1, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz lcgbwbeiwtib = { xnnowhszwjsj, { 0, 2, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz wmibezdihnyi = { snzmmpcjdzjo, { 1, 2, 0x01, 0, zwhtoeafiyoe } };
static const struct lmbejlluhdlz fkpxcrqrnjct = { khavbnzeldsl, { 0, 10, 0x01, 0, ajvrfjpbcfpo } };
static const struct lmbejlluhdlz kqdefetwjhjv = { jhsulolqpzko, { 0, 3, 0x1F, 0, nopqffvtmuyp } };
static const struct lmbejlluhdlz dcwqifidhzed = { khavbnzeldsl, { 1, 3, 0xFF, 0, moawowkntgnf } };
static const struct lmbejlluhdlz ozrsiabmdpow = { ubhfwqahykef, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz fgzixfgwbxdg = { kwajdgzvnbjj, { 3, 6, 0x01, 0, lkbznxqiesiz } };
static const struct lmbejlluhdlz svnlxylljumb = { oqbuigucoivc, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz ijghsafyduzk = { xnnowhszwjsj, { 1, 10, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz xvbyrkpbudok = { kwajdgzvnbjj, { 1, 6, 0x01, 0, lkbznxqiesiz } };
static const struct lmbejlluhdlz dpfoulglkedq = { kwajdgzvnbjj, { 2, 6, 0x01, 0, lkbznxqiesiz } };
static const struct lmbejlluhdlz vgevvsinesjt = { boateqjhekfw, { 0, 12, 0x04, 2, zubvwxaeucxc } };
static const struct lmbejlluhdlz sfkelpzmrzlt = { xnnowhszwjsj, { 1, 1, 0x04, 2, xrjajgppykcz } };
static const struct lmbejlluhdlz gqprjzhldwak = { xnnowhszwjsj, { 0, 10, 0x02, 1, xrjajgppykcz } };
static const struct lmbejlluhdlz wkkhzutktiar = { woarbopqeuss, { 0, 8, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz hkkqfoobgpse = { jhsulolqpzko, { 0, 10, 0x3e, 1, szssavgevhep } };
static const struct lmbejlluhdlz nvxftztlbfva = { xnnowhszwjsj, { 0, 7, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz oidzjbaffppw = { xnnowhszwjsj, { 1, 0, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz zcmrxrykszxm = { jhsulolqpzko, { 0, 12, 0x1f, 0, yyhvlmpuooub } };
static const struct lmbejlluhdlz nbuuzstcaeoz = { woarbopqeuss, { 0, 7, 0x01, 0, zwhtoeafiyoe } };
static const struct lmbejlluhdlz frweqmdbkymq = { rebnlonfabes, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz axiqbypxjfhm = { woarbopqeuss, { 0, 9, 0x01, 0, btjhitcgorwo } };
static const struct lmbejlluhdlz sspynytwwfik = { xnnowhszwjsj, { 0, 3, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz zbvpuzkthise = { boateqjhekfw, { 0, 11, 0x7F, 0, zutwmokafppz } };
static const struct lmbejlluhdlz iloffpvlgzkj = { xnnowhszwjsj, { 0, 0, 0x01, 0, xrjajgppykcz } };
static const struct lmbejlluhdlz gcleefidtsko = { woarbopqeuss, { 0, 2, 0x01, 0, btjhitcgorwo } };
static const struct lmbejlluhdlz vwfarzudiigm = { woarbopqeuss, { 0, 7, 0x04, 2, wyvotfszqwoi } };
static const struct lmbejlluhdlz xvegdynzcuvy = { kwajdgzvnbjj, { 2, 2, 0x20, 5, lkbznxqiesiz } };
static const struct lmbejlluhdlz lclohufezpej = { kwajdgzvnbjj, { 2, 3, 0x80, 7, lkbznxqiesiz } };
static const struct lmbejlluhdlz sncfvqpnwjrp = { dxbkjwurnkbr, { 1, 12, 0x01, 0, xtnefcleezay } };
static const struct lmbejlluhdlz ljqcvrliuqjk = { khavbnzeldsl, { 1, 4, 0x01, 0, ajvrfjpbcfpo } };
static const struct lmbejlluhdlz rtffdvmqipbu = { boateqjhekfw, { 0, 11, 0xff, 0, bjtbyvcgrnyn } };
static const struct lmbejlluhdlz bolofrnxfnbs = { iebzljjbytvu, { 2, 3, 0x80, 7, vivhnporwyvr } };
static const struct lmbejlluhdlz bqkzfnmkxtcv = { jhsulolqpzko, { 0, 12, 0x1f, 0, tbvexvgfibqd } };
static const struct lmbejlluhdlz vgwixyosijik = { boateqjhekfw, { 1, 12, 0x04, 2, zubvwxaeucxc } };
static const struct lmbejlluhdlz wjzlthcmibqi = { pbmggltoeadc, { 1, 2, 0xf0, 4, zregqnqoosue } };
static const struct lmbejlluhdlz gmkvvfrakhod = { woarbopqeuss, { 0, 7, 0x10, 4, btjhitcgorwo } };
static const struct lmbejlluhdlz xpgydpokyfek = { woarbopqeuss, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz vykyyrqsvkjg = { gkjyomlkmapd, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz tzdolwhmeely = { powivspfcatk, { 1, 5, 0x01, 0, stkftkqdgzbe } };
static const struct lmbejlluhdlz keeqekzpzmuf = { boateqjhekfw, { 0, 9, 0x40, 6, zubvwxaeucxc } };
static const struct lmbejlluhdlz fkehplcygkhw = { woarbopqeuss, { 1, 0, 0x01, 0, btjhitcgorwo } };
static const struct lmbejlluhdlz hmweyrenjagm = { powivspfcatk, { 1, 7, 0x10, 4, stkftkqdgzbe } };
static const struct lmbejlluhdlz ltbihlmrbgbz = { jhsulolqpzko, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz volufrrpyips = { hrjqivghsgfj, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz icccxsqevewz = { pbmggltoeadc, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz fkcfehqixyem = { woarbopqeuss, { 3, 3, 0x01, 0, btjhitcgorwo } };
static const struct lmbejlluhdlz hfosnmdagufh = { ojwvoytgirzo, { 0, 4, 0x01, 0, azddxtjyeqae } };
static const struct lmbejlluhdlz cwquszmpyrvp = { jhsulolqpzko, { 0, 5, 0x0f, 0, sctqntkdamav } };
static const struct lmbejlluhdlz usoclgqcnwde = { xnnowhszwjsj, { 0, 3, 0x01, 0, btjhitcgorwo } };
static const struct lmbejlluhdlz hjctogzkgskg = { xnnowhszwjsj, { 1, 3, 0x01, 0, zwhtoeafiyoe } };
static const struct lmbejlluhdlz eeoztqejihpd = { nyqpjbbxtmgf, { 0, 0, 0, 0, NULL } };
static const struct lmbejlluhdlz iagydowakuyr = { woarbopqeuss, { 0, 13, 0x01, 0, zwhtoeafiyoe } };
static const struct lmbejlluhdlz xiomrpyxzinu = { khavbnzeldsl, { 0, 0, 0, 0, NULL } };
static const struct hydvnyvlqvbd lwcszlhgilko = { 0x00, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct hydvnyvlqvbd asltysbmhayz = { 0x11, 0, -3, 2, {0, 1, 0, 0}, 1, -1, 0, 0 };
static const struct hydvnyvlqvbd cbjxtprkjysp = { 0x22, 1, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct hydvnyvlqvbd vaiquegurqvj = { 0x33, 0, -3, 2, {0, 1, 0, 0}, 3, -1, 0, 0 };
static const struct hydvnyvlqvbd rdqxlnbshwbb = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct hydvnyvlqvbd lxwkfqbvwtly = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xff };
static const struct hydvnyvlqvbd mujgnqsiauvw = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 1, 0xff };
static const struct hydvnyvlqvbd tkuuiktrnnao = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd bldsmqetrdgr = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct hydvnyvlqvbd dssctmrfautr = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct hydvnyvlqvbd xbrqnwgayxlg = { 0x33, 0, -1, 1, {0, 0, 0, 0}, 3, 0, 0, 0x0 };
static const struct hydvnyvlqvbd pfcaxwwztvkf = { 0x00, 0, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd mqznkpdtkdgn = { 0x11, 0, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd oattbtwishim = { 0x22, 0, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd gaeghtursbti = { 0x00, 0, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct hydvnyvlqvbd cjuetmbkbirk = { 0x00, 1, -2, 4, {1, 0, 0, 1}, 0, 2, 0xff, 0xff };
static const struct hydvnyvlqvbd rstsvoztsoeo = { 0x00, 0, -1, 2, {0, 0, 0, 1}, 0, 1, 0xff, 0 };
static const struct hydvnyvlqvbd jawdthdyeret = { 0x22, 0, -1, 2, {0, 0, 0, 1}, 2, 1, 0xff, 0 };
static const struct hydvnyvlqvbd zeohuaapxjkx = { 0x00, 0, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd numjjqplmbpo = { 0x11, 0, -1, 1, {1, 0, 0, 0}, 1, 0, 0, 0x0 };
static const struct hydvnyvlqvbd tikoeffqsdxa = { 0x22, 0, -1, 1, {1, 0, 0, 0}, 2, 0, 0, 0x0 };
static const struct hydvnyvlqvbd kkbcxfjhkxsm = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 1, 0, 0xff, 0 };
static const struct hydvnyvlqvbd cbyjbjwvxlsy = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct hydvnyvlqvbd iglbrgachqfv = { 0x22, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct hydvnyvlqvbd zjvhuoiylrlr = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd mtmctrdvrsmb = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf8 };
static const struct hydvnyvlqvbd ciiqfzvjntdd = { 0x00, 0, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0xf2 };
static const struct hydvnyvlqvbd qymvfbuvmcak = { 0x11, 0, -2, 1, {0, 0, 1, 0}, 1, 0, 0, 0x0 };
static const struct hydvnyvlqvbd khsxazpvltcp = { 0x00, 1, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd qsqcaokajytf = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 3, 0, 0xff };
static const struct hydvnyvlqvbd eqmyzmfuveus = { 0, 0, 0xff, 0, {6, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct hydvnyvlqvbd afzpvnrfgket = { 0, 0, 0xff, 0, {0, 0, 0, 0}, 0, 4, 0, 0xff };
static const struct hydvnyvlqvbd dmoizojqkclx = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct hydvnyvlqvbd wcgkvtelwfvl = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x02 };
static const struct hydvnyvlqvbd onpjnpueauae = { 0x00, 0, -2, 1, {0, 0, 0, 0}, 0, -1, 0, 0x0 };
static const struct hydvnyvlqvbd ihmifjqqcylw = { 0x00, 3, -1, 2, {1, 0, 0, 1}, 0, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd qvwbyqzmppaq = { 0x11, 3, -1, 2, {1, 0, 0, 1}, 1, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd amjxuqcwehmo = { 0x22, 3, -1, 2, {1, 0, 0, 1}, 2, 1, 0xff, 0xff };
static const struct hydvnyvlqvbd utruwhipdisq = { 0x00, 1, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct hydvnyvlqvbd uolczdhllxsj = { 0x00, 0, 0, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct hydvnyvlqvbd wqmifjifswgk = { 0x00, 0, 0, 1, {0, 0, 0, 1}, 2, 0, 0xff, 0 };
static const struct hydvnyvlqvbd mlfhepumbfia = { 0x11, 0, 0, 1, {0, 0, 0, 1}, 3, 0, 0xff, 0 };
static const struct hydvnyvlqvbd gyevecddbmez = { 0x11, 0, 0, 1, {1, 0, 0, 1}, 2, 0, 0xff, 0xff };
static const struct hydvnyvlqvbd vtpzmforppns = { 0x00, 5, -10, 1, {0, 0, 1, 0}, 0, -4, 0, 0x0 };
static const struct hydvnyvlqvbd bpsdiccliemi = { 0x00, 5, -2, 1, {0, 0, 1, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd qdssbenintfq = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 6, 0x0 };
static const struct hydvnyvlqvbd sjjglgrjgwef = { 0x00, 0, -1, 1, {6, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd iwofwbdwzzhw = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 3 };
static const struct hydvnyvlqvbd ezahxrukkjvi = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0xfe };
static const struct hydvnyvlqvbd ijodkmyvrtrs = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x08 };
static const struct hydvnyvlqvbd jjswvicnijnp = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x88 };
static const struct hydvnyvlqvbd teoqfvsbhuuy = { 2, 0, 0x0f, 0, {0, 0, 0, 0}, 0, 3, 0, 0x0f };
static const struct hydvnyvlqvbd fastsvyvweek = { 0x00, 0, -1, 1, {10, 0, 0, 0}, 0, 0, 0, 0 };
static const struct hydvnyvlqvbd tkxcghwaowxr = { 0x00, 0, -3, 1, {0, 0, 0, 1}, 1, 4, 0xff, 0 };
static const struct hydvnyvlqvbd kuzdaproxgfc = { 0x11, 8, -9, 1, {0, 0, 0, 1}, 2, -2, 0xff, 0 };
static const struct hydvnyvlqvbd ajxpjpuraahb = { 0x11, 0, -13, 2, {0, 1, 0, 0}, 1, -11, 0, 0 };
static const struct hydvnyvlqvbd byiafvzfmoxl = { 0x11, 9, 0, 2, {0, 0, 0, 0}, -1, 0, 0, 8 };
static const struct hydvnyvlqvbd ptaydzzqtant = { 0x22, 0, -13, 2, {0, 1, 0, 0}, 2, -11, 0, 0 };
static const struct hydvnyvlqvbd zhrumiixvnvq = { 0x00, 0, 0, 1, {0, 0, 0, 0}, 1, -1, 0, 0 };
static const struct hydvnyvlqvbd wdolzhwocoup = { 0x00, 4, -1, 1, {1, 0, 0, 0}, 0, 0, 0, 0x0 };
static const struct hydvnyvlqvbd rrabcczvoocz = { 0x00, 0, -1, 1, {12, 0, 0, 0}, 0, 0, 11, 0x0 };
static const struct hydvnyvlqvbd qusojrvmpgyn = { 0x00, 0, -1, 1, {13, 0, 0, 0}, 0, 0, 4, 2 };
static const struct hydvnyvlqvbd qyhflsugbvxa = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct hydvnyvlqvbd estghoucrtzd = { 0x22, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 0, 0x0 };
static const struct hydvnyvlqvbd hxvdbajxrrqg = { 0x11, 1, 0, 1, {13, 1, 0, 0}, 1, -5, 1, 0xFF };
static const struct hydvnyvlqvbd xflxnukideot = { 0x33, 1, 0, 1, {13, 1, 0, 0}, 3, -5, 1, 0xFF };
static const struct hydvnyvlqvbd icvmudcksqjk = { 0x00, 0, -1, 1, {6, 0, 0, 0}, -1, 0, 0, 0x7f };
static const struct hydvnyvlqvbd jyxyslkoiemo = { 0x00, 0xff, 0, 1, {0, 1, 0, 0}, 0, 0, 1, 0x2c };
static const struct hydvnyvlqvbd zfmfjfjpbcqs = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 1, 0xaa };
static const struct hydvnyvlqvbd moonabebcgxk = { 0x11, 1, 0, 1, {1, 0, 0, 1}, 0, 0, 0xff, 0xff };
static const struct hydvnyvlqvbd utcvofytegnk = { 0, 0, 3, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct hydvnyvlqvbd zggedoglpfgl = { 0, 0, 8, 0, {0, 0, 0, 0}, 0, 0, 0, 0 };
static const struct hydvnyvlqvbd cxiflsfakyqs = { 0x00, 0, -5, 1, {14, 0, 0, 0}, 1, -5, 0, 0xfc };
static const struct hydvnyvlqvbd oxcdzhihpepa = { 0x00, 0, 0, 1, {13, 0, 0, 0}, -1, 0, 4, 7 };
static const struct hydvnyvlqvbd babtcqfcdary = { 0x00, 0xff, -1, 1, {0, 1, 0, 0}, 1, 0, 1, 0x80 };
static const struct hydvnyvlqvbd fkvcfdrvobib = { 0x00, 0, -1, 1, {1, 0, 0, 1}, 1, 0, 0xff, 0xff };
static const struct hydvnyvlqvbd aiyxhdwgqans = { 0x11, 0, -1, 1, {0, 0, 0, 0}, 1, 0, 0, 0x09 };
static const struct hydvnyvlqvbd iqexzvsvnmyv = { 0x22, 0, -1, 1, {0, 0, 0, 0}, 2, 0, 0, 0xF1 };
static const struct hydvnyvlqvbd wxqksfwhuugp = { 0x11, 0, 0, 1, {0, 0, 0, 0}, 0, -1, 0, 0 };
static const struct hydvnyvlqvbd uydruefmmrup = { 0x00, 0, -1, 1, {0, 0, 0, 0}, 0, 0, 0, 0x54 };
static const struct fcnkovzmnnhc oilkehratgid[] = { { bcoifiiosqkn,	&rdqxlnbshwbb }, { gwwrdzbufaji,	&lwcszlhgilko }, { gwwrdzbufaji,	&asltysbmhayz }, { gwwrdzbufaji,	&cbjxtprkjysp }, { gwwrdzbufaji,	&vaiquegurqvj }, {NULL, NULL} };
static const struct fcnkovzmnnhc wjnwwcjvdatg[] = { { gwwrdzbufaji,	&lwcszlhgilko }, { gwwrdzbufaji,	&asltysbmhayz }, {NULL, NULL} };
static const struct fcnkovzmnnhc fvzpivxekuqk[] = { { bcoifiiosqkn,	&lxwkfqbvwtly }, {NULL, NULL} };
static const struct fcnkovzmnnhc pgkfblaqcowv[] = { { gwwrdzbufaji,	&lxwkfqbvwtly }, {NULL, NULL} };
static const struct fcnkovzmnnhc czblcwvndhot[] = { { bcoifiiosqkn,	&tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc igxhjdrvywam[] = { { bcoifiiosqkn,	&tkuuiktrnnao }, { bcoifiiosqkn,	&bldsmqetrdgr }, {NULL, NULL} };
static const struct fcnkovzmnnhc ffcmssmueytf[] = { { bcoifiiosqkn,	&bldsmqetrdgr }, { bcoifiiosqkn,	&dssctmrfautr }, { bcoifiiosqkn,	&xbrqnwgayxlg }, {NULL, NULL} };
static const struct fcnkovzmnnhc ndnhvunsikoa[] = { {NULL, NULL} };
static const struct fcnkovzmnnhc wgxxnrxllosg[] = { { bcoifiiosqkn, &zeohuaapxjkx}, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc mebltbcdobtk[] = { { gwwrdzbufaji,	&zjvhuoiylrlr }, {NULL, NULL} };
static const struct fcnkovzmnnhc hcghivuzrpmj[] = { { gwwrdzbufaji,	&qymvfbuvmcak }, {NULL, NULL} };
static const struct fcnkovzmnnhc qfsbalqlnmum[] = { { bcoifiiosqkn, &pfcaxwwztvkf }, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc ksntmuuzguel[] = { { bcoifiiosqkn, &pfcaxwwztvkf }, {NULL, NULL} };
static const struct fcnkovzmnnhc bjxkhzdelqda[] = { { diwayqtuqhlk,	&tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc giyhkblgxico[] = { { diwayqtuqhlk,	&tkuuiktrnnao }, { diwayqtuqhlk,	&bldsmqetrdgr }, {NULL, NULL} };
static const struct fcnkovzmnnhc itfrywyiwemi[] = { { gwwrdzbufaji,	&zjvhuoiylrlr }, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc clckwhrtozge[] = { { bcoifiiosqkn, &rstsvoztsoeo}, { bcoifiiosqkn, &jawdthdyeret}, { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &iglbrgachqfv}, {NULL, NULL} };
static const struct fcnkovzmnnhc ltfxabhetpae[] = { { bcoifiiosqkn, &zeohuaapxjkx}, {NULL, NULL} };
static const struct fcnkovzmnnhc hombefjfkgvl[] = { { bcoifiiosqkn, &pfcaxwwztvkf}, { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &dssctmrfautr}, {NULL, NULL} };
static const struct fcnkovzmnnhc dzjaxehfbhfv[] = { { bcoifiiosqkn, &pfcaxwwztvkf}, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc xyzmfiirhiqv[] = { { bcoifiiosqkn, &khsxazpvltcp}, {NULL, NULL} };
static const struct fcnkovzmnnhc syekfxhtfhwt[] = { { gwwrdzbufaji,	&zjvhuoiylrlr }, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc ugeujihichum[] = { { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc jtjaworrdkzn[] = { { diwayqtuqhlk,	&lxwkfqbvwtly }, {NULL, NULL} };
static const struct fcnkovzmnnhc osafzqfgbvoy[] = { { rtvwetswdyac,	&qsqcaokajytf }, { bcoifiiosqkn,	&tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc yfarnqjkwnfa[] = { { rtvwetswdyac,	&eqmyzmfuveus }, { bcoifiiosqkn,	&tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc cmmaprdbgnua[] = { { rtvwetswdyac,	&afzpvnrfgket }, { bcoifiiosqkn,	&tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc hojheepfghni[] = { { bcoifiiosqkn, &uolczdhllxsj}, {NULL, NULL} };
static const struct fcnkovzmnnhc vhutgysqfljg[] = { { gwwrdzbufaji,	&mtmctrdvrsmb }, {NULL, NULL} };
static const struct fcnkovzmnnhc vsjfqnukiezq[] = { { gwwrdzbufaji,	&ciiqfzvjntdd }, {NULL, NULL} };
static const struct fcnkovzmnnhc vcehntjfaucl[] = { { gwwrdzbufaji,	&dmoizojqkclx }, {NULL, NULL} };
static const struct fcnkovzmnnhc geqprwnpiqkn[] = { { gwwrdzbufaji,	&wcgkvtelwfvl }, {NULL, NULL} };
static const struct fcnkovzmnnhc bgzdumfejgds[] = { { bcoifiiosqkn,	&numjjqplmbpo }, { bcoifiiosqkn,	&tikoeffqsdxa }, {NULL, NULL} };
static const struct fcnkovzmnnhc igqtdsgitzoh[] = { { bcoifiiosqkn,	&bldsmqetrdgr }, {NULL, NULL} };
static const struct fcnkovzmnnhc nrttivxguiho[] = { { bcoifiiosqkn, &numjjqplmbpo}, {NULL, NULL} };
static const struct fcnkovzmnnhc lfhmumvqjfmw[] = { { bcoifiiosqkn, &mqznkpdtkdgn}, {NULL, NULL} };
static const struct fcnkovzmnnhc qfbkamgabynw[] = { { bcoifiiosqkn, &onpjnpueauae}, {NULL, NULL} };
static const struct fcnkovzmnnhc npxtikjoeikw[] = { { bcoifiiosqkn, &ihmifjqqcylw}, { bcoifiiosqkn, &qvwbyqzmppaq}, { bcoifiiosqkn, &amjxuqcwehmo}, {NULL, NULL} };
static const struct fcnkovzmnnhc ggczcwxmunin[] = { { diwayqtuqhlk, &cxiflsfakyqs}, { diwayqtuqhlk, &utruwhipdisq}, { bcoifiiosqkn, &wqmifjifswgk}, {NULL, NULL} };
static const struct fcnkovzmnnhc lwdawtvwyymu[] = { { bcoifiiosqkn,	&tkuuiktrnnao }, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc ddjsplzhrtxm[] = { { bcoifiiosqkn, &gyevecddbmez}, {NULL, NULL} };
static const struct fcnkovzmnnhc lnctpfcenogx[] = { { diwayqtuqhlk,	&vtpzmforppns }, { diwayqtuqhlk,	&bpsdiccliemi }, {NULL, NULL} };
static const struct fcnkovzmnnhc gjxebyvdvqox[] = { { bcoifiiosqkn, &rstsvoztsoeo}, { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &cbyjbjwvxlsy}, {NULL, NULL} };
static const struct fcnkovzmnnhc joaemonkmxrp[] = { { diwayqtuqhlk,	&bpsdiccliemi }, {NULL, NULL} };
static const struct fcnkovzmnnhc rfuodgfprtbp[] = { { bcoifiiosqkn, &qdssbenintfq}, {NULL, NULL} };
static const struct fcnkovzmnnhc eiwjvqfivinv[] = { { bcoifiiosqkn, &sjjglgrjgwef}, {NULL, NULL} };
static const struct fcnkovzmnnhc eywapiiglxig[] = { { bcoifiiosqkn, &mqznkpdtkdgn }, {NULL, NULL} };
static const struct fcnkovzmnnhc ibemvitqxulw[] = { { bcoifiiosqkn, &mujgnqsiauvw }, {NULL, NULL} };
static const struct fcnkovzmnnhc nxxkpocakeer[] = { { bcoifiiosqkn, &iwofwbdwzzhw }, {NULL, NULL} };
static const struct fcnkovzmnnhc pjmpysxxvgih[] = { { bcoifiiosqkn, &jjswvicnijnp }, {NULL, NULL} };
static const struct fcnkovzmnnhc mrvqonwscbcw[] = { { bcoifiiosqkn, &bldsmqetrdgr }, { bcoifiiosqkn, &dssctmrfautr }, {NULL, NULL} };
static const struct fcnkovzmnnhc kkrphttycecy[] = { { diwayqtuqhlk, &ezahxrukkjvi }, {NULL, NULL} };
static const struct fcnkovzmnnhc gosteyduspss[] = { { rtvwetswdyac,	&teoqfvsbhuuy }, { bcoifiiosqkn, &uolczdhllxsj}, { bcoifiiosqkn, &wqmifjifswgk}, {NULL, NULL} };
static const struct fcnkovzmnnhc kaoazvneauzk[] = { { diwayqtuqhlk, &ijodkmyvrtrs }, {NULL, NULL} };
static const struct fcnkovzmnnhc lcwkklzlvqfk[] = { { rtvwetswdyac,	&teoqfvsbhuuy }, {NULL, NULL} };
static const struct fcnkovzmnnhc nfsmzyppyfrp[] = { { gwwrdzbufaji,	&qymvfbuvmcak }, { bcoifiiosqkn, &wqmifjifswgk}, { bcoifiiosqkn, &mlfhepumbfia}, {NULL, NULL} };
static const struct fcnkovzmnnhc ggtbngwedvnv[] = { { bcoifiiosqkn,	&lxwkfqbvwtly }, { bcoifiiosqkn, &kkbcxfjhkxsm}, {NULL, NULL} };
static const struct fcnkovzmnnhc malrkmeqrwmb[] = { { bcoifiiosqkn,	&fastsvyvweek }, {NULL, NULL} };
static const struct fcnkovzmnnhc zojrkykrpxnk[] = { { bcoifiiosqkn, &wqmifjifswgk}, { bcoifiiosqkn, &mlfhepumbfia}, {NULL, NULL} };
static const struct fcnkovzmnnhc bjtkknsuuyti[] = { { bcoifiiosqkn, &pfcaxwwztvkf}, { bcoifiiosqkn, &kkbcxfjhkxsm}, {bcoifiiosqkn, &oattbtwishim}, {NULL, NULL} };
static const struct fcnkovzmnnhc ciqwjzqbjrek[] = { { gwwrdzbufaji, &tkuuiktrnnao }, {NULL, NULL} };
static const struct fcnkovzmnnhc ivuepqetauuu[] = { { bcoifiiosqkn, &gaeghtursbti}, { bcoifiiosqkn, &cjuetmbkbirk}, {NULL, NULL} };
static const struct fcnkovzmnnhc gyvkurmqtjgv[] = { { bcoifiiosqkn,	&tkxcghwaowxr }, { gwwrdzbufaji,	&lwcszlhgilko }, { gwwrdzbufaji,	&ajxpjpuraahb }, { gwwrdzbufaji,	&byiafvzfmoxl }, { gwwrdzbufaji,	&ptaydzzqtant }, {NULL, NULL} };
static const struct fcnkovzmnnhc tlssicamrhrl[] = { { uwbzrprspcpi, &zhrumiixvnvq}, {NULL, NULL} };
static const struct fcnkovzmnnhc gsmtbuovbyaf[] = { { bcoifiiosqkn, &zhrumiixvnvq}, {NULL, NULL} };
static const struct fcnkovzmnnhc ekerqtujxlsh[] = { { bcoifiiosqkn, &wdolzhwocoup}, { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &iglbrgachqfv}, {NULL, NULL} };
static const struct fcnkovzmnnhc tepikmqypoha[] = { { bcoifiiosqkn, &rrabcczvoocz}, { bcoifiiosqkn, &uolczdhllxsj}, {NULL, NULL} };
static const struct fcnkovzmnnhc vehpzgezvach[] = { { bcoifiiosqkn, &qyhflsugbvxa}, { bcoifiiosqkn, &hxvdbajxrrqg}, { bcoifiiosqkn, &estghoucrtzd}, { bcoifiiosqkn, &xflxnukideot}, {NULL, NULL} };
static const struct fcnkovzmnnhc sifulwqeulvu[] = { { bcoifiiosqkn, &qyhflsugbvxa}, { bcoifiiosqkn, &hxvdbajxrrqg}, { bcoifiiosqkn, &qyhflsugbvxa}, { bcoifiiosqkn, &xflxnukideot}, {NULL, NULL} };
static const struct fcnkovzmnnhc kbrdlavnrake[] = { { bcoifiiosqkn, &qyhflsugbvxa}, { bcoifiiosqkn, &hxvdbajxrrqg}, {NULL, NULL} };
static const struct fcnkovzmnnhc wsbjubuhhksr[] = { { bcoifiiosqkn, &icvmudcksqjk}, { bcoifiiosqkn, &jyxyslkoiemo}, {NULL, NULL} };
static const struct fcnkovzmnnhc sptnttmtlvun[] = { { bcoifiiosqkn, &zfmfjfjpbcqs}, {NULL, NULL} };
static const struct fcnkovzmnnhc kxuqubvzffbt[] = { { diwayqtuqhlk, &zeohuaapxjkx}, {NULL, NULL} };
static const struct fcnkovzmnnhc gmvsypoheoui[] = { { bcoifiiosqkn, &moonabebcgxk}, { bcoifiiosqkn, &wqmifjifswgk}, {NULL, NULL} };
static const struct fcnkovzmnnhc fwseuthvpykb[] = { { bcoifiiosqkn,	&tkuuiktrnnao }, { bcoifiiosqkn,	&uolczdhllxsj }, { bcoifiiosqkn,	&wqmifjifswgk }, {NULL, NULL} };
static const struct fcnkovzmnnhc gmefryrjqpxw[] = { { gwwrdzbufaji, &zeohuaapxjkx}, {NULL, NULL} };
static const struct fcnkovzmnnhc wdiwmiuvusjg[] = { { bcoifiiosqkn, &mqznkpdtkdgn }, { bcoifiiosqkn, &cbyjbjwvxlsy}, {NULL, NULL} };
static const struct fcnkovzmnnhc joiqzgqdrshc[] = { { frfdpomjrbop, &utcvofytegnk}, {NULL, NULL} };
static const struct fcnkovzmnnhc litmtotzgcwv[] = { { frfdpomjrbop, &zggedoglpfgl}, {NULL, NULL} };
static const struct fcnkovzmnnhc fwtvtkvhxwyl[] = { { gwwrdzbufaji, &mqznkpdtkdgn}, { bcoifiiosqkn, &mlfhepumbfia}, { NULL, NULL} };
static const struct fcnkovzmnnhc cudbvananeib[] = { { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &cbyjbjwvxlsy}, {NULL, NULL} };
static const struct fcnkovzmnnhc aaqdnsdafnoh[] = { { bcoifiiosqkn, &oxcdzhihpepa}, { bcoifiiosqkn, &babtcqfcdary}, {NULL, NULL} };
static const struct fcnkovzmnnhc iczmyxkcwwqr[] = { { diwayqtuqhlk, &zeohuaapxjkx}, { bcoifiiosqkn, &kkbcxfjhkxsm}, { bcoifiiosqkn, &cbyjbjwvxlsy}, {NULL, NULL} };
static const struct fcnkovzmnnhc wmyhhyzoejor[] = { { bcoifiiosqkn,	&tkuuiktrnnao }, { bcoifiiosqkn,	&fkvcfdrvobib }, { bcoifiiosqkn,	&aiyxhdwgqans }, { bcoifiiosqkn,	&wqmifjifswgk }, {NULL, NULL} };
static const struct fcnkovzmnnhc fynhkcltizeb[] = { { bcoifiiosqkn, &pfcaxwwztvkf}, { gwwrdzbufaji, &mqznkpdtkdgn}, { bcoifiiosqkn, &wqmifjifswgk}, { bcoifiiosqkn, &mlfhepumbfia}, {NULL, NULL} };
static const struct fcnkovzmnnhc xjzgzmasebbq[] = { { gwwrdzbufaji, &mqznkpdtkdgn}, {NULL, NULL} };
static const struct fcnkovzmnnhc nhhwiyuxkfjo[] = { { bcoifiiosqkn, &bldsmqetrdgr }, { bcoifiiosqkn, &iqexzvsvnmyv }, {NULL, NULL} };
static const struct fcnkovzmnnhc estftcmkqfof[] = { { diwayqtuqhlk, &wxqksfwhuugp}, {NULL, NULL} };
static const struct fcnkovzmnnhc plljdoetcfhs[] = { { bcoifiiosqkn,	&kuzdaproxgfc }, { bcoifiiosqkn,	&bldsmqetrdgr }, { bcoifiiosqkn,   &dssctmrfautr }, {NULL, NULL} };
static const struct fcnkovzmnnhc uohctvovsvci[] = { { bcoifiiosqkn, &uydruefmmrup}, {NULL, NULL} };
static const struct fcnkovzmnnhc kbcaoyuymqjy[] = { { diwayqtuqhlk, &sjjglgrjgwef}, { gwwrdzbufaji, &mujgnqsiauvw}, {NULL, NULL} };
static const struct fcnkovzmnnhc vqtkjssfeyaz[] = { { bcoifiiosqkn, &qusojrvmpgyn}, {NULL, NULL} };
static const struct fcnkovzmnnhc kxlyncbrsfvl[] = { { gwwrdzbufaji, &mujgnqsiauvw}, {NULL, NULL} };
static const char* PREDEFINDED_NAMES[] = { "M96b (XIAOMI/TCL)", "M100b (SHINCO/SAMSUNG/ELECTROLUX)", "T102b (WHIRLPOOL/BOSCH/AIRWELL)", "M128b (FUJITSU/McQUAY/TICA)", "M56b (TRUMA)" };
static const bc7215FormatPkt_t qnjwemvunutx[] = { {{.inByte=0x34}, {0x14, 0x1d, 0x10, 0xfd, 0x14, 0x1d, 0x09, 0xfd, 0x9c, 0x9c, 0x12, 0x0a, 0x77, 0x9d, 0x38, 0xf8, 0x00, 0x00, 0xfa, 0x7f, 0xb5, 0x1a, 0x97, 0x02, 0x48, 0x00, 0x3e, 0x01, 0x48, 0x00, 0xea, 0x00}}, {{.inByte=0x35}, {0x13, 0x9D, 0x24, 0xDD, 0x13, 0x7D, 0x69, 0x3D, 0x9D, 0x1D, 0x2E, 0xDB, 0xF2, 0x9B, 0xBD, 0xFE, 0x0F, 0x02, 0xCE, 0x5F, 0x81, 0x3A, 0xA3, 0x22, 0x74, 0x00, 0x75, 0x05, 0x73, 0x00, 0x26, 0x13}}, {{.inByte=0x21}, {0x10, 0xBD, 0x06, 0x5D, 0x06, 0x5D, 0x2B, 0x9D, 0x1F, 0x19, 0x35, 0x4D, 0x1A, 0xA7, 0x72, 0xF9, 0x00, 0x00, 0x22, 0x00, 0x44, 0x00, 0x66, 0x90, 0x0D, 0x00, 0x0A, 0x00, 0x48, 0x00, 0x39, 0x00}}, {{.inByte=0x36}, {0x1B, 0x1D, 0x17, 0xFD, 0x18, 0xBD, 0x0F, 0xBD, 0x9F, 0x1E, 0x5F, 0x83, 0x83, 0xC9, 0x2B, 0xFB, 0x84, 0x00, 0x84, 0x10, 0x06, 0x01, 0x90, 0x02, 0x2D, 0x00, 0xF5, 0x08, 0x13, 0x02, 0x2F, 0x03}}, {{.inByte=0x37}, {0x15, 0xDD, 0x0C, 0x7D, 0x0C, 0x3D, 0x04, 0xFD, 0x1F, 0x9F, 0x92, 0x88, 0x19, 0x22, 0xCB, 0xF8, 0x00, 0x80, 0x00, 0x10, 0xA9, 0x9A, 0x8B, 0x82, 0x37, 0xC3, 0x81, 0x8A, 0x21, 0xE7, 0x01, 0x20}} };
static const uint8_t dryukgejxayc[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x1c, 0x26, 0x10, 0x00, 0x4a};
static const uint8_t ghnqidxhwspi[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xC4, 0x12, 0x40, 0x0C};
static const uint8_t bxvncgpwyybk[] = {0x66, 0x00, 0x1C, 0x16, 0x00, 0x00, 0x87, 0x05, 0x80, 0x00, 0x21, 0xC1, 0x60, 0x00, 0x08};
static const uint8_t fmuqklygwdwl[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x50, 0x10, 0x04, 0x14, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t drmkmimdncrq[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const uint8_t cbmotsociirf[] = {0x60, 0x00, 0x9e, 0xc8, 0x00, 0x04, 0x52, 0x60, 0x00, 0x8c, 0x26, 0x10, 0x00, 0xda};
static const uint8_t gsssqlyflxkf[] = {0x64, 0x00, 0x02, 0x05, 0x2C, 0x04, 0xD5, 0x56, 0x01, 0x6C, 0x50, 0xD0, 0x12, 0x40, 0x0C};
static const uint8_t hefcnjudanon[] = {0x66, 0x00, 0x1C, 0x14, 0x00, 0x00, 0x87, 0x05, 0x00, 0x00, 0x21, 0xC1, 0x40, 0x00, 0x08};
static const uint8_t jagoiejiulzi[] = {0x06, 0x01, 0x53, 0x04, 0x10, 0x04, 0x14, 0x10, 0x04, 0x00, 0x00, 0x04, 0x00, 0x04, 0x44, 0x10, 0x04, 0x10, 0x09, 0x00, 0x00, 0x00, 0x00, 0x50, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x50, 0x25};
static const uint8_t obahrykuwtci[] = {0x38, 0x00, 0xE9, 0x0D, 0x10, 0x00, 0x00, 0x00, 0x06};
static const bc7215DataVarPkt_t* epyuhudmrosj[] = { (bc7215DataVarPkt_t*)cbmotsociirf, (bc7215DataVarPkt_t*)gsssqlyflxkf, (bc7215DataVarPkt_t*)hefcnjudanon, (bc7215DataVarPkt_t*)jagoiejiulzi, (bc7215DataVarPkt_t*)obahrykuwtci };
static const bc7215DataVarPkt_t* ooaftaidqqgg[] = { (bc7215DataVarPkt_t*)dryukgejxayc, (bc7215DataVarPkt_t*)ghnqidxhwspi, (bc7215DataVarPkt_t*)bxvncgpwyybk, (bc7215DataVarPkt_t*)fmuqklygwdwl, (bc7215DataVarPkt_t*)drmkmimdncrq };
static const uint8_t ijtbuxyjlwcl = sizeof(epyuhudmrosj)/sizeof(struct bc7215DataVarPkt_t*);
static const uint8_t jklpqvoiftkz[] = {0x23, 0xCB, 0x26};
static const uint8_t gktarqxjpekq[] = {0x02, 0x20, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x06};
static const uint8_t qixkoejkuics[] = {0x00, 0x00, 0x36, 0x1B, 0x5D, 0x12, 0x3D, 0x1B, 0x7D, 0x02, 0x9D, 0x1F, 0x9E, 0x21, 0x60, 0x06, 0x53, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x21, 0x0F, 0xC6, 0x0F, 0x20, 0x0F, 0xC6, 0x0F, 0x3F, 0x50, 0x60, 0x00, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x4d, 0xb2, 0xde, 0x21, 0x07, 0xf8, 0x00, 0x00};
static const uint8_t guclibnijadf[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0x0f, 0x00, 0x00};
static const uint8_t pxibuiehrwol[] = {0x28, 0x00, 0x68, 0xc2, 0x3d, 0x0f, 0xf0, 0x28, 0x00, 0x68, 0x12, 0xed, 0x0f, 0xf0};
static const uint8_t tfzdbsvbvcbx[] = {0xB8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6, 0x16, 0xe9, 0x01, 0xfe, 0xa0, 0x5f, 0xb8, 0x00, 0x01, 0x10, 0x00, 0x40, 0xbf, 0xff, 0x00, 0xe6, 0x19, 0x89, 0x76, 0x01, 0xfe, 0x3f, 0xc0, 0x29, 0xd6,  0x16, 0xe9, 0x01, 0xfe, 0x90, 0x6f};
static const uint8_t nwjarwwisfjy[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x80, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x09, 0x30, 0xa1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0e};
static const uint8_t sppjsrhnokms[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t embnmdrdqphz[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x90, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x0b, 0x41, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x03, 0x20};
static const uint8_t wgniorglrypz[] = {0x38, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0xfd, 0x08, 0x01, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfe, 0x1a, 0x40, 0x89, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x10, 0x24, 0x00, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0x00, 0xac};
static const uint8_t lrsrbesgrqom[] = {0x30, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0x02, 0x78, 0x00, 0x14, 0x63, 0x00, 0x10, 0x10, 0xfc, 0x08, 0x30, 0x91, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3e};
static const uint8_t hqwmeruostxl[] = {0x20, 0x00, 0x14, 0xeb, 0xc1, 0x3e, 0x40, 0x00, 0x14, 0xeb, 0x98, 0x91, 0x04, 0x00, 0x00, 0x00};
static const uint8_t jxljgfhervmx[] = {0x48, 0x00, 0x1C, 0x28, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x48, 0x00, 0x1C, 0x24, 0x49, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1a};
static const uint8_t lufulicjnyck[] = {0x00, 0x00, 0x33, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1E, 0x9B, 0x19, 0x9F, 0x2A, 0xA8, 0x07, 0x31, 0x00, 0x80, 0x00, 0x10, 0x38, 0x20, 0x38, 0x10, 0x70, 0x20, 0x70, 0x10, 0x3E, 0x87, 0x30, 0x00, 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0};
static const uint8_t uuglrllwxjhy[] = {0x00, 0x00, 0x30, 0x1A, 0xDD, 0x13, 0xBD, 0x1A, 0x7D, 0x01, 0x9D, 0x1F, 0x98, 0x37, 0xB0, 0x07, 0x2B, 0xAA, 0xF8, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x70, 0x10, 0x70, 0x00, 0x9E, 0x4A, 0x3E, 0x27, 0x39, 0x0D  , 0xa8, 0x00, 0x02, 0xb2, 0x0f, 0x00, 0x00, 0x00, 0xc0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0xff, 0x71, 0x80, 0x11, 0xc0, 0xa8, 0x00, 0x02, 0x92, 0x0f, 0x00, 0x00, 0x00, 0xf0, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe2, 0xfe, 0x71, 0x80, 0x11, 0xf0};
static const uint8_t ryokukpjfgch[] = {0x00, 0x00, 0x36, 0x1A, 0x1D, 0x13, 0x1D, 0x1A, 0x1D, 0x01, 0x3D, 0x1F, 0x9E, 0x37, 0xB5, 0x07, 0x07, 0x4C, 0xFB, 0x00, 0x00, 0x38, 0x10, 0x38, 0x00, 0x94, 0xE2, 0x28, 0xA3, 0x9E, 0xEA, 0x3E, 0x87, 0x0D, 0x0A, 0x70, 0x00, 0x01, 0xd2, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x01, 0x22, 0xff, 0x01, 0xa0, 0x11, 0xc0, 0x00, 0x00 };
static const uint8_t sxthzfmpbrjb[] = {0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x53, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x4E, 0x60, 0x00, 0x6A, 0xF5, 0x79, 0x20, 0x00, 0x93, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x52};
static const uint8_t erkbbiwelcmy[] = {0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x43, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x46, 0x70, 0x00, 0x6A, 0x55, 0x79, 0x20, 0x00, 0x83, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x21, 0x00, 0x4a};
static const uint8_t igcwaisxjzoc[] = {0x00, 0x00, 0x36, 0x15, 0xBD, 0x12, 0xFD, 0x15, 0x5D, 0x03, 0x9D, 0x1F, 0x9E, 0x23, 0x61, 0x08, 0x4F, 0xAA, 0xF8, 0x00, 0x00, 0x90, 0x10, 0x90, 0x00, 0x4E, 0x0F, 0x39, 0x0F, 0x31, 0x0F, 0x36, 0x0F, 0xFF, 0x4D, 0x20, 0x01, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x4F, 0xB0, 0x30, 0xCF, 0x90, 0x2E, 0x20, 0x80, 0x70, 0xAA, 0x10, 0xDA, 0x40, 0x84, 0xD6, 0x84, 0xAE, 0x36, 0x00, 0x00};
static const uint8_t odprdqbfxjko[] = {0x00, 0x00, 0x36, 0x15, 0x9D, 0x12, 0xDD, 0x15, 0x9D, 0x02, 0x1D, 0x1F, 0x9E, 0x22, 0x63, 0x08, 0x51, 0xAA, 0xF8, 0x00, 0x00, 0x30, 0x10, 0x30, 0x00, 0x4C, 0x0F, 0x0F, 0x0F, 0x4C, 0x0F, 0xBE, 0x0F, 0xFF, 0x4D, 0x60, 0x00, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x4D, 0xB2, 0xDE, 0x21, 0x07, 0xF8, 0x00, 0x00};
static const extraValue_t nbdnkukqfqmu = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t bulclcezozas = {.set={0x14, 0x0f, 0x10, 0x24, 0x13, 0x24, NULL}};
static const extraValue_t hdhadpgqjwdv = {.set={0x13, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t itvvutspwqkz = {.set={0x10, 0x0f, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t tnzlmvpodknl = {.set={0x10, 0x24, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t btskbanpruvy = {.set={0x14, 0x00, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t hwmmdrygbfas = {.set={0x13, 0x20, 0xf0, 0xf0, 0xf0, 0xf0, NULL}};
static const extraValue_t qwdcybrpkpwf = {.set={0x10, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t srzgqpiynuni = {.set={0x10, 0x00, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t ehbtnshbflmy = {.set={0x10, 0x0f, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t alafjlhsckiu = {.set={0x10, 0x00, 0x13, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t okxbejklxnat = {.set={0x13, 0x0f, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t ugjpaihlyruf = {.set={0x10, 0x00, 0x13, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t zuaxiuysvzqe = {.set={0x13, 0x20, 0x14, 0x0f, 0xf0, 0xf0, NULL}};
static const extraValue_t yexwjtvednlb = {.set={0x10, 0x0f, 0x14, 0x00, 0xf0, 0xf0, NULL}};
static const extraValue_t nbtqmbshmoln = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, NULL}};
static const extraValue_t hoseydcoikyy = {.set={0x13, 0x0f, 0x14, 0x01, 0xf0, 0xf0, NULL}};
static const extraValue_t imgevadfbvyb = {.set={0x92, 0x0f, 0x13, 0x24, 0xf0, 0xf0, NULL}};
static const extraValue_t wwdcudhjbcjc = {.set={0x10, 0x00, 0x13, 0x00, 0x13, 0x20, NULL}};
static const extraValue_t cxwhixryrtfz = {.set={0x10, 0x00, 0x92, 0x02, 0x13, 0x20, NULL}};
static const extraValue_t zkpwghmcxqkx= {.set={0x10, 0x0f, 0x92, 0x40, 0x92, 0x21, NULL}};
static const extraValue_t ucvhwaogzzmm = {.set={0x30, 0x2f, 0x31, 0x2f, 0xf0, 0xf0, NULL}};
static const extraValue_t hxdmgzppieqr = {.set={0x72, 0x2f, 0x32, 0x24, 0xf0, 0xf0, NULL}};
static const extraValue_t pawyltzpximt = {.set={0x72, 0x1f, 0x72, 0x2f, 0xf0, 0xf0, NULL}};
static const extraValue_t zmsfrckyfkzy = {.set={0x14, 0x0f, 0x10, 0x0f, 0xf0, 0xf0, aobcwiazgkkt}};
static const extraValue_t hbufkhovsarz= {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, decolzmcqreo}};
static const extraValue_t aukwbujumwmr = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, faryrwqvegui}};
static const extraValue_t bbxpnsrdzinc = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, fyxckfrcbimd}};
static const extraValue_t grfxrbdiwsvt = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, gibhnwvjibkv}};
static const extraValue_t pikumtrjbono = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, gxtkkxjobxml}};
static const extraValue_t hwdkadparycc = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, jmetxlpoaeek}};
static const extraValue_t uytamwzgxgtg = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, exfyfjaljvjh}};
static const extraValue_t wdolqoxxzcjd = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, odohypyaydjs}};
static const extraValue_t fvjvlzkzeava = {.set={0x13, 0x0f, 0x13, 0x20, 0xf0, 0xf0, ripziuuuphym}};
static const extraValue_t hbcwtlayojwf = {.set={0x91, 0x2f, 0x91, 0x09, 0xf0, 0xf0, ndnejedmebyw}};
static const extraValue_t tvgeaystgvul = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, yefgpcnbeoqm}};
static const extraValue_t kcojmoonhiie = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, lwgmjdzuimtg}};
static const struct rsvujpsrigrz biyiikwonuqe;
static const struct rsvujpsrigrz xtozzsbzrkwo;
static const struct rsvujpsrigrz imouaeoeqrhr;
static const struct rsvujpsrigrz umqbqlubovkd;
static const struct rsvujpsrigrz epsqsvzmjoij;
static const struct rsvujpsrigrz irxydjyuqjfh;
static const struct rsvujpsrigrz cvpvnunedldm;
static const struct rsvujpsrigrz vveskdcbytgr;
static const extraValue_t rxawcdbrablz = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&biyiikwonuqe}};
static const extraValue_t zboepmyxeiyj = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&xtozzsbzrkwo}};
static const extraValue_t bvohqzxijlym = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&imouaeoeqrhr}};
static const extraValue_t npvhjfqssakq = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&umqbqlubovkd}};
static const extraValue_t yhtmypmhossg = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&epsqsvzmjoij}};
static const extraValue_t umtzlcknmpju = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&irxydjyuqjfh}};
static const extraValue_t qcfrsqpvdsul = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&cvpvnunedldm}};
static const extraValue_t vxemyucvhvvc = {.set={0xf0, 0xf0, 0xf0, 0xf0, 0xf0, 0xf0, (const rbpeihvtnuyd*)&vveskdcbytgr}};
static const extraValue_t qjqyhmworaxm = {.aevxhrsgdbyw={82, 13, 0, 0}};
static const struct gpbqxitaiizd hphrihomgvhs = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 134, {35,32,35,32}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0, 0, 0x07, 0, oqmqtbrtarwr }, { 0x83, 2, 0x70, 4, xmpbznnszzgm }, { 0, 0, 0x30, 4, tgtfklffchvs }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, oilkehratgid, NULL };
static const struct gpbqxitaiizd ewddpgbncxwr = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 67, {35,32,0,0}, { 0, 1, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, wjnwwcjvdatg, &fefkuoviwtks };
static const struct gpbqxitaiizd uqdnhwcyeiyn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd byqanbrxskph = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 216, {64,152,0,0}, { 1, 6, 0x1E, 1, cmntsrwmylfh }, { 1, 5, 0x70, 4, oprimmhycskq }, { 1, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd kmnwvjvjdwvq = { {0, 0, 0 , 0, 0, 0, 0}, 0x34, 43, {43,0,0,0}, { 0, 1, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 0, 0x70, 4, kuwjmesodnrm}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 3, 0x70}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd gghmehwbbirj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, uwhhynzlqhub}, { 0, 0, 0x07, 0, dflwnjfakmyn}, { 0, 0, 0x30, 4, zveummuuqpoh}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd conthumzlpco = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, uwhhynzlqhub}, { 0, 0, 0x07, 0, suqrsgzbyjrl}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd niyxkpniwohx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, suqrsgzbyjrl}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd rlzksymkktib = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 52, {52,0,0,0}, { 0, 5, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, suqrsgzbyjrl}, { 0, 0, 0x30, 4, zveummuuqpoh}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd dgybpdvkzaps = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, cmntsrwmylfh}, { 0, 1, 0x07, 0, oqmqtbrtarwr}, { 0, 1, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ggtbngwedvnv, NULL };
static const struct rsvujpsrigrz xtozzsbzrkwo = {NULL, &dgybpdvkzaps, 1, 255};
static const struct gpbqxitaiizd owpyysmsawlz = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0x0f, 0, cmntsrwmylfh}, { 0, 1, 0x07, 0, oqmqtbrtarwr}, { 0, 1, 0x30, 4, nvjodrzzlddk}, { 0x80, 0, 0, 0, NULL}, &zboepmyxeiyj, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, fvzpivxekuqk, NULL };
static const struct gpbqxitaiizd turkmfyaperg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, ytbrcludyvxf}, { 0, 6, 0xe0, 5, tghruybtsqpf}, { 0, 4, 0xe0, 5, ssgjvfhyuect}, { 0, 11, 0x07, 0, haylvzeejxtf}, &zmsfrckyfkzy, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 9, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &hkkqfoobgpse };
static const struct gpbqxitaiizd jdicjwykokzq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 1, 0xf8, 3, ytbrcludyvxf}, { 0, 6, 0xe0, 5, tghruybtsqpf}, { 0, 4, 0xe0, 5, davjvkjsdpah}, { 0, 11, 0x07, 0, haylvzeejxtf}, &zmsfrckyfkzy, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 9, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd vwyuehyhjkcu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 8, 0xff, 0, ypgweitsalat}, { 0, 0, 0xf0, 4, tafrsqjnefqd}, { 0, 9, 0x03, 0, nvjodrzzlddk}, { 0, 0, 0x07, 0, okxlgwwojlqc}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd fnhhryoehnkz = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 144, {72, 72, 0, 0}, { 0, 5, 0xf0, 4, uwhhynzlqhub}, { 0, 6, 0x07, 0, lmlgvjpkpdnq}, { 0, 6, 0xC0, 6, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x06}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, wgxxnrxllosg, NULL };
static const struct gpbqxitaiizd nrkxomwlhjue = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0, 4, 0x70, 4, rqbgjoqmfipj }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 5, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, mebltbcdobtk, &keeqekzpzmuf };
static const struct gpbqxitaiizd yzkicewtgtzx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &vgevvsinesjt };
static const struct gpbqxitaiizd nopmvthazrfx = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &rtffdvmqipbu };
static const struct gpbqxitaiizd ysfajdvqhgew = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, cfszeinxwraw }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd qkbnuoiosxhe = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, wqremrbmlwyg }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &bqkzfnmkxtcv };
static const struct gpbqxitaiizd scmhgpfuqwlk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, tlilvvzkpkzg }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, wqremrbmlwyg }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd qytehikcoevs = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, skkuscfhnkez}, { 0, 2, 0x07, 0, wrrnxlvsulqv}, { 0, 0, 0xe0, 5, eqyztsfcxhky}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd shutefsgttuf = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct}, { 0, 2, 0x07, 0, fsrpwjnnruda}, { 0, 0, 0xe0, 5, srmirchdvmvy}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd hkowiktqhfzs = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct}, { 0, 2, 0x07, 0, wrrnxlvsulqv}, { 0, 0, 0xC0, 6, hbkwawzvifnd}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd mmuaruzhkbtc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct}, { 0, 2, 0x07, 0, fsrpwjnnruda}, { 0, 0, 0xC0, 6, hbkwawzvifnd}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd fhjasrdyfcqc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct}, { 0, 2, 0x0f, 0, qwkmptnrpjag}, { 0, 0, 0xff, 0, fvnvesgvmmts}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd ehcntcgyyfbs = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 48, {48, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct}, { 0, 2, 0x07, 0, fsrpwjnnruda}, { 0, 0, 0xe0, 5, kgysironeztb}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd aeloimaxwamf = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 4, 0x0f, 0, gcajumhjzbzp }, { 0, 4, 0x30, 4, ojeoftlzgpeq }, { 0, 2, 0x07, 0, sndrvydgwxhi }, { 0, 0, 0, 0, NULL}, &bulclcezozas, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 2, 0xde}, .gecmoisvuikh.aqpwroyoznxu = {{0, 8}, 4, 0x07}}, qfsbalqlnmum, &ozrsiabmdpow };
static const struct gpbqxitaiizd axtlhgesujwz = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0xFE, 1, pzskpnrdiidk }, { 1, 5, 0x70, 4, hhtcymniazqt }, { 1, 10, 0x0f, 0, cxneheyfiqpy }, { 0, 0, 0, 0, NULL}, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd kqussebgshnu = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xfe, 1, sknaonxhcbby }, { 1, 5, 0x70, 4, oprimmhycskq}, { 1, 8, 0xf0, 4, cxneheyfiqpy}, { 0, 0, 0, 0, NULL}, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igxhjdrvywam, &xvbyrkpbudok };
static const struct gpbqxitaiizd bystkddanudk = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, sknaonxhcbby }, { 3, 5, 0x70, 4, oprimmhycskq }, { 3, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{3, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{3, 9}, 9, 0x0f}}, ffcmssmueytf, &fgzixfgwbxdg };
static const struct gpbqxitaiizd pxyxjilgbnvi = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, ypgweitsalat }, { 0, 1, 0x70, 4, oqmqtbrtarwr }, { 0, 2, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &itvvutspwqkz, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x0f}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, pjmpysxxvgih, NULL };
static const struct gpbqxitaiizd ahnbwbztlaqb = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 128, {128, 0, 0, 0}, { 0, 0x83, 0xff, 0, ypgweitsalat }, { 0, 1, 0x70, 4, oqmqtbrtarwr }, { 0, 2, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x0f}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd oqhkfplzqygm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, cmntsrwmylfh }, { 0, 0, 0x70, 4, pihojjvoszmj }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 1}, 0, 0x07}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd xzdtjuaiwpmf = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0x0f, 0, tsdmfgpfasfa }, { 0, 0, 0x70, 4, pihojjvoszmj }, { 0, 1, 0x70, 4, zwozxthnnebr }, { 0, 0, 0x0f, 0, giocrwpysbgq }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 1}, 0, 0x07}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd ilbhxnaabzyg = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 80, {40, 40, 0, 0}, { 0, 0x1, 0xff, 0, ypgweitsalat }, { 0x00, 0, 0x07, 0, ayoirfczdouv }, { 0, 0, 0x30, 6, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,8},1,0x16}}, ugeujihichum, NULL };
static const struct rsvujpsrigrz imouaeoeqrhr = {NULL, &ilbhxnaabzyg, 1, 165};
static const struct gpbqxitaiizd nwskzajjztey = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, ypgweitsalat }, { 0, 0, 0x07, 0, ayoirfczdouv }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0x80, 0, 0, 0, NULL }, &bvohqzxijlym, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,8},1,0x16}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd ztoopuwhxaqb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 0x1, 0x0f, 0, tsdmfgpfasfa }, { 0, 2, 0x60, 5, oqmqtbrtarwr }, { 0, 3, 0xc0, 6, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd tkcwqlinwpwt = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 0x0, 0xff, 0, tjjeosglowtn }, { 0, 4, 0xf0, 4, kobtotblliyt }, { 0, 7, 0x0f, 0, ypgaghxzmqrw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bjxkhzdelqda, NULL };
static const struct gpbqxitaiizd jizgqpswgmzb = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 64, {32,32,0,0}, { 0, 2, 0x0f, 0, cmntsrwmylfh }, { 0, 0, 0x0f, 0, mzesnovedksd }, { 0, 2, 0xf0, 4, pmgsyczkuvvk }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, itfrywyiwemi, NULL };
static const struct gpbqxitaiizd fzzwckumztwv = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, tsdmfgpfasfa }, { 0x00, 2, 0x07, 0, amjlwwtuumqb }, { 0, 0, 0xf0, 4, zqtslcvzjlbs }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, clckwhrtozge, NULL };
static const struct gpbqxitaiizd amzykpfpkgmc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 0x2, 0x0f, 0, cmntsrwmylfh }, { 0x00, 10, 0x07, 0, buvyfaternak }, { 0, 4, 0x70, 4, laidcvjzjwzt }, { 0, 12, 0x07, 0, sftvyfwssldz }, &hbufkhovsarz, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 3, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ltfxabhetpae, NULL };
static const struct gpbqxitaiizd fmcgdzmybgln = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, cjspeajeetae }, { 0x00, 4, 0x0c, 2, dvpuldozuwvu }, { 0x80, 2, 0xe0, 5, tahcygxlrqmp }, { 2, 1, 0xff, 0, bhularavlxpf }, &bulclcezozas, {.lztusevbiwbk = (const bc7215DataVarPkt_t*)qixkoejkuics}, hombefjfkgvl, &xvegdynzcuvy };
static const struct gpbqxitaiizd swapplqzmyny = { {1, 0, 1, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 4, 0xf0, 4, cjspeajeetae }, { 0x00, 4, 0x0c, 2, dvpuldozuwvu }, { 0x80, 2, 0xe0, 5, wqcopogbpbpz }, { 2, 1, 0xff, 0, ngyffxnglrbo }, &bulclcezozas, {.lztusevbiwbk = (const bc7215DataVarPkt_t*)qixkoejkuics}, hombefjfkgvl, NULL };
static const struct gpbqxitaiizd sqfmtqvmyrer = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, quywhrfyrrqx }, { 0x00, 1, 0x70, 4, oqmqtbrtarwr }, { 0x40, 3, 0xf0, 4, ypgaghxzmqrw }, { 0, 3, 0x0f, 0, eckwleyifbuy }, &ucvhwaogzzmm, {.lztusevbiwbk = (bc7215DataVarPkt_t*)guclibnijadf}, xyzmfiirhiqv, NULL };
static const struct gpbqxitaiizd bhbpgboyvqgk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x80, 0, 0x0f, 0, rtblkcmfhvfv }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 4, 0x40, 6, opbubkswvgez }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd zcgrmptqmmjc = { {0, 1, 0, 0, 0, 0, 0}, 0x3e, 129, {64, 65, 0, 0}, { 0, 2, 0x1e, 1, cmntsrwmylfh }, { 0x0, 1, 0x07, 0, csgmjvbkkwah }, { 0, 1, 0x70, 4, ujorjtjrsrec }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x30}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 5, 0xc0}}, syekfxhtfhwt, NULL };
static const struct gpbqxitaiizd rxhcbhfnaspr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0x07, 0, iirqplykcsjl }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd whfuafrlctxn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x0, 0, 0x70, 4, svyugtaogvsg }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 1}, 0, 0x0f}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd qilghsfijxad = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 80, {80, 0, 0, 0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0x0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0x07, 0, iirqplykcsjl }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd lmvlflntnzep = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x0, 0, 0x70, 4, svyugtaogvsg }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 1}, 0, 0x0f}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd pknydaggdioj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0x0f, 0, buwyjftobvfj }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd auftxbzqnwfz = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 112, {16, 40, 16, 40}, { 1, 3, 0xf0, 4, cmntsrwmylfh }, { 0x81, 0, 0xc0, 6, utmyxoywjjgs }, { 1, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0xc0, 6, lwzdjhevyehp }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 0, 0xc0}}, fynhkcltizeb, NULL };
static const struct gpbqxitaiizd whncwjlxhzko = { {0, 0, 1, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0x40, 3, 0xf0, 4, cmntsrwmylfh }, { 0x0, 1, 0x70, 4, oqmqtbrtarwr }, { 0, 3, 0xf0, 4, ypgaghxzmqrw }, { 0, 3, 0x0f, 0, wxzfgfvwifep }, &hxdmgzppieqr, {.lztusevbiwbk = (bc7215DataVarPkt_t*)pxibuiehrwol}, xyzmfiirhiqv, NULL };
static const struct gpbqxitaiizd kquuumnhfdbm = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0x0f, 0, zbyuugoskdnw }, { 0x0, 3, 0x70, 4, lmlgvjpkpdnq }, { 0, 2, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &alafjlhsckiu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd ynocknvbwvtr = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &fkpxcrqrnjct };
static const struct gpbqxitaiizd gxxgvlluztbh = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &aukwbujumwmr, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 10, 0x10}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd lohwxfaygqon = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 160, {112, 48, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &bbxpnsrdzinc, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 10, 0x10}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd cugrippztfgq = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 0x1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 6, 0xf0, 4, xvlibyqkrdrf }, { 0, 5, 0xc0, 6, zveummuuqpoh }, { 0, 1, 0x07, 0, vqztcbnniyep }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &svnlxylljumb };
static const struct gpbqxitaiizd oflcnphcchko = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 136, {112, 24, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd nanbjalaeuvy = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 6, 0xe0, 5, kdtknwphwltk }, { 0, 5, 0xe0, 5, iudqvuwwzzfo }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd gvztlymvwvps = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 88, {88, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 6, 0xe0, 5, kdtknwphwltk }, { 0, 4, 0xe0, 5, ssgjvfhyuect }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, osafzqfgbvoy, NULL };
static const struct gpbqxitaiizd usczmayaroaj = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0x0, 5, 0x70, 4, llwlyvriyeuj }, { 0, 4, 0x07, 0, wzkubwkdaosj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 0, 0x02}}, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd xhlnpjkuuphv = { {1, 1, 0, 0, 0, 0 ,0}, 0x37, 64, {16, 48, 0, 0}, { 1, 3, 0xf0, 4, cmntsrwmylfh }, { 1, 5, 0xe0, 5, zpdorivacyev }, { 1, 1, 0x30, 4, kpjntihjrmdt }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, xjzgzmasebbq, NULL };
static const struct gpbqxitaiizd rloqmdbazvhi = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 4, 0xFF, 0, zefptmbzmdcl }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 8}, 12, 5}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd jdcputcrozvk = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x0f, 0, itplntpkarzz }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x2f}}, yfarnqjkwnfa, NULL };
static const struct gpbqxitaiizd cuxbkomreukb = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x0f, 0, itplntpkarzz }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0xf0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 6}}, cmmaprdbgnua, NULL };
static const struct gpbqxitaiizd bcjwagxugurw = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, cmntsrwmylfh }, { 0x0, 2, 0x70, 4, ycdmpncfihnp }, { 0, 1, 0x30, 4, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, hojheepfghni, NULL };
static const struct gpbqxitaiizd fcifwqeiweis = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, lkcleczckmqs }, { 0x0, 5, 0xf0, 4, rgwtgswgpuya }, { 0, 5, 0x0f, 0, onpxavfvifmb }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 8, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, vhutgysqfljg, NULL };
static const struct gpbqxitaiizd lzecgkhtywuj = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, tsdmfgpfasfa }, { 0, 1, 0x07, 0, nhuuaeatpxut }, { 0, 2, 0x07, 0, evgslnjlbbxv }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, vcehntjfaucl, &iyuladpyuyeb };
static const struct gpbqxitaiizd sgkrgxkklxlv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, skkuscfhnkez }, { 0x0, 8, 0xe0, 5, fsrpwjnnruda }, { 0, 6, 0x60, 5, hbkwawzvifnd }, { 0, 4, 0x07, 0, vdllhntvjrzl }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x07}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd flekhblsejmg = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, skkuscfhnkez }, { 0x0, 8, 0xe0, 5, fsrpwjnnruda }, { 0, 6, 0x60, 5, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x07}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd slbylqnqgvzc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, skkuscfhnkez }, { 0x0, 4, 0x07, 0, gmsvovqvqsnb }, { 0, 6, 0x60, 5, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x07}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd ocuzxmnpigwa = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x0f, 0, skkuscfhnkez }, { 0x0, 8, 0xe0, 5, fsrpwjnnruda }, { 0, 6, 0xe0, 5, srmirchdvmvy }, { 0, 4, 0x07, 0, vdllhntvjrzl }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x07}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd eoldtcyeugkk = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, furrpwcvfmwl }, { 1, 1, 0x07, 0, glchtfgsebbd }, { 1, 0, 0x03, 0, zveummuuqpoh }, { 2, 1, 0xff, 0, cgirezmuuzsl }, &grfxrbdiwsvt, {.gecmoisvuikh.lnrpcoyamxnd = {{2, 9}, 4, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bgzdumfejgds, NULL };
static const struct gpbqxitaiizd qdghbpwfnjkz = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 112, {16, 96, 0, 0}, { 1, 1, 0xf0, 4, furrpwcvfmwl }, { 1, 1, 0x07, 0, glchtfgsebbd }, { 1, 0, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 0, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, nrttivxguiho, NULL };
static const struct gpbqxitaiizd yhzoahnqpxxh = { {0, 1, 0, 0 ,0, 0 ,0}, 0x34, 184, {24, 160, 0, 0}, { 1, 3, 0xff, 0, amamuejctadz }, { 1, 0, 0x3f, 0, xtoiikraetvd }, { 1, 1, 0xff, 0, uyhcrzyfqrbd }, { 1, 16, 0xff, 0, szqejexuipzr }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, nrttivxguiho, NULL };
static const struct gpbqxitaiizd gwjlpjolsvmk = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, furrpwcvfmwl }, { 0, 3, 0x07, 0, glchtfgsebbd }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, &svnlxylljumb };
static const struct gpbqxitaiizd gvwsmjdfamfj = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 3, 0xf0, 4, cmntsrwmylfh }, { 0, 3, 0x07, 0, glchtfgsebbd }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct ojyxxaaevkqk nevfrdekzqai = { .hxzmznxdkbkc = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 168, {24, 144, 0, 0}, { 1, 12, 0xfe, 1, duwlxejfbcur }, { 1, 14, 0x0f, 0, dmwkqflvmzup }, { 1, 14, 0xf0, 4, kbeiscfdapob }, { 1, 8, 0x0f, 0, lrvtylfsvlro }, &nbdnkukqfqmu, {.cikjcvnkgdnt = rejsmncfbtyb}, lfhmumvqjfmw, &sncfvqpnwjrp }, .yzanflvvuasy = dmwkqflvmzup };
static const struct gpbqxitaiizd xycuwfxxcifd = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 136, {24, 112, 0, 0}, { 0x41, 12, 0xfe, 1, duwlxejfbcur }, { 0x61, 12, 0x0f, 0, (const uint8_t*)&nevfrdekzqai }, { 1, 12, 0xf0, 4, kbeiscfdapob }, { 1, 8, 0x0f, 0, lrvtylfsvlro }, &pawyltzpximt, {.lztusevbiwbk = (bc7215DataVarPkt_t*)tfzdbsvbvcbx}, lfhmumvqjfmw, &sncfvqpnwjrp };
static const struct gpbqxitaiizd gdydrjmbjxrr = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0, 4, 0x30, 4, qnmyddjmgedp }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 5, 0x40}}, mebltbcdobtk, &svnlxylljumb };
static const struct gpbqxitaiizd agddqiceqteq = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, furrpwcvfmwl }, { 0, 3, 0x07, 0, glchtfgsebbd }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd aloiqjwdwtgo = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0xf0, 4, furrpwcvfmwl }, { 0, 3, 0x07, 0, glchtfgsebbd }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &cwquszmpyrvp };
static const struct gpbqxitaiizd jckvfqucizfw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 4, 0x30, 4, qnmyddjmgedp }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 2, 0xff, 0, rexdwghznmmj }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 5, 0x40}}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd yjolkncjhqgu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0x0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0x0f, 0, buwyjftobvfj }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd apdcsqgbxjhb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0x0f, 0, furrpwcvfmwl }, { 0x0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0x0f, 0, buwyjftobvfj }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd qxtksxilpous = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 4, 0x30, 4, jjkxidtpszvy }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 2, 0x10, 4, dskfsdqvpsfm }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3},5, 0x04}}, bjxkhzdelqda, &ozrsiabmdpow };
static const struct gpbqxitaiizd ahyjutgpitfo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 4, 0x30, 4, qnmyddjmgedp }, { 0, 4, 0x0c, 2, eerwapzvukix }, { 0, 2, 0xff, 0, ezzphgiiazhk }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 5, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 5, 0x80}}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd iyxycrjlgsai = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 4, 0x30, 4, qnmyddjmgedp }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 2, 0x10, 4, dskfsdqvpsfm }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 1, 0x02}}, bjxkhzdelqda, NULL };
static const struct gpbqxitaiizd akwhlnficqin = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 12, 0xff, 0, uhabhvecnpgk}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &zcmrxrykszxm };
static const struct gpbqxitaiizd weunfbwsltgs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 113, {113, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez}, { 0, 6, 0x0f, 0, jnioisscmtak}, { 0, 8, 0x07, 0, kfiokuecrvod}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, qfbkamgabynw, NULL };
static const struct gpbqxitaiizd rtlpqmnkilcd = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0, 5, 0xf0, 4, hrxdawpyshai }, { 0, 3, 0x03, 0, nvjodrzzlddk }, { 0, 5, 0x20, 5, hmzbnjtrewvr }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, npxtikjoeikw, NULL };
static const struct gpbqxitaiizd oimjaqywsigs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0x80, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 8, 0xf8, 0, resqxheahzcf }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd bzvdugxbvdra = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 168, {56, 56, 56, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0, 5, 0xf0, 4, qskjfhumgdxg }, { 0, 3, 0x03, 0, zveummuuqpoh }, { 0, 5, 0x20, 5, hmzbnjtrewvr }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, npxtikjoeikw, NULL };
static const struct gpbqxitaiizd brreygbdnbop = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xff, 0, zkrqupjjpcjj }, { 0, 0, 0x07, 0, suqrsgzbyjrl }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd crvxozwprecv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0, 0, 0x07, 0, suqrsgzbyjrl }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd kxkdrkbjaolu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0, 0, 0x70, 4, suqrsgzbyjrl }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 1}, 0, 0x87}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd wycbqpfredhu = { {1, 0, 0, 1, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 7, 0x1e, 1, cmntsrwmylfh }, { 0, 5, 0x07, 0, oqmqtbrtarwr }, { 0, 6, 0xff, 0, azexlyfhzmjp }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ltfxabhetpae, NULL };
static const struct gpbqxitaiizd quaugbthkggk = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 224, {112, 112, 0, 0}, { 1, 7, 0x0f, 0, skkuscfhnkez }, { 1, 6, 0x0f, 0, jnioisscmtak }, { 0x01, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1,9},5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, igqtdsgitzoh, &vgwixyosijik };
static const struct gpbqxitaiizd frvdprgwgrle = { {1, 1, 0, 0, 0, 0, 0}, 0x35, 88, {44, 44, 0, 0}, { 0, 0x1, 0xff, 0, ypgweitsalat }, { 0x00, 0, 0x07, 0, ayoirfczdouv }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ugeujihichum, NULL };
static const struct rsvujpsrigrz umqbqlubovkd = {NULL, &frvdprgwgrle, 1, 165};
static const struct gpbqxitaiizd kpbcfrfbfkdq = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 0x1, 0xff, 0, ypgweitsalat }, { 0x00, 0, 0x07, 0, ayoirfczdouv }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0x80, 0, 0, 0, NULL }, &npvhjfqssakq, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd erpekfehcrhs = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, kuyqbnkbyxpc }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0, 2, 0x0f, 0, xcjqyivqssjo }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9},0,0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ggczcwxmunin, NULL };
static const struct gpbqxitaiizd zsfkmkycjmkh = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, oqkgqijxnddh }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0, 2, 0x0f, 0, hghxsrwbzetq }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9},0,0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ggczcwxmunin, NULL };
static const struct gpbqxitaiizd gkbppxpzkaye = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, oqkgqijxnddh }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0, 2, 0x0f, 0, xcjqyivqssjo }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9},0,0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ggczcwxmunin, NULL };
static const struct gpbqxitaiizd ydjjygjuwvjw = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 60, {20, 20, 20, 0}, { 0, 0x1, 0x0f, 0, tpncdzkkpnwf }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0, 2, 0x0f, 0, hghxsrwbzetq }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9},0,0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ggczcwxmunin, NULL };
static const struct gpbqxitaiizd hjfbwjbtaeci = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 288, {144, 144, 0, 0}, { 0, 7, 0x0f, 0, cmntsrwmylfh }, { 0x80, 6, 0x38, 3, iexxstwfurfd }, { 0, 9, 0x07, 0, kuwjmesodnrm }, { 0, 8, 0x07, 0, iahlckzwlqlv }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lwdawtvwyymu, &gmkvvfrakhod };
static const struct gpbqxitaiizd jxydsfilacuj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 144, {144, 0, 0, 0}, { 0, 7, 0x0f, 0, cmntsrwmylfh }, { 0x80, 6, 0x38, 3, iexxstwfurfd }, { 0, 9, 0x07, 0, kuwjmesodnrm }, { 0, 8, 0x07, 0, iahlckzwlqlv }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd cvvxzetagjzo = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, skkuscfhnkez }, { 0x1, 6, 0x07, 0, iexxstwfurfd }, { 1, 8, 0x07, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd ablknklbhmyf = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 184, {40, 144, 0, 0}, { 1, 7, 0x0f, 0, cmntsrwmylfh }, { 0x81, 6, 0x38, 3, jnioisscmtak }, { 1, 9, 0x03, 0, nvjodrzzlddk }, { 1, 8, 0x07, 0, iahlckzwlqlv }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igqtdsgitzoh, &hmweyrenjagm };
static const struct gpbqxitaiizd vhkdfhlnkvog = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, pcarcrbepsfm }, { 1, 6, 0x07, 0, fsrpwjnnruda }, { 1, 4, 0xe0, 5, jjupysshyxnm }, { 0, 0, 0, 0, NULL }, &srzgqpiynuni, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{1,3},6,0x08}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd tyctbkebajmz = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 1, 0xf0, 4, cmntsrwmylfh }, { 1, 1, 0x07, 0, edxqfohleqap }, { 1, 2, 0x06, 1, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ddjsplzhrtxm, &vykyyrqsvkjg };
static const struct gpbqxitaiizd pbutyhykyfli = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 136, {40, 48, 48, 0}, { 1, 0, 0x1e, 1, cmntsrwmylfh }, { 1, 1, 0x07, 0, edxqfohleqap }, { 1, 2, 0x06, 1, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ddjsplzhrtxm, &fkehplcygkhw };
static const struct gpbqxitaiizd kayrjhfjefdr = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 102, {51, 51, 0, 0}, { 0, 2, 0xf0, 4, skkuscfhnkez }, { 0, 1, 0x0f, 0, jnioisscmtak }, { 0, 2, 0x07, 0, xmpbznnszzgm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ugeujihichum, &xpgydpokyfek };
static const struct gpbqxitaiizd pverbdfjbynw = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct }, { 0x0, 2, 0x07, 0, wrrnxlvsulqv }, { 0, 0, 0x70, 4, mwgxuyotwelz }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd yjbaxhjiasht = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, vcslgboymbrm }, { 1, 6, 0x07, 0, fsrpwjnnruda }, { 1, 4, 0xe0, 5, jjupysshyxnm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 6, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd skfmovwktrrq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 6, 0xf0, 4, ontgfftakrct }, { 1, 6, 0x07, 0, fsrpwjnnruda }, { 1, 4, 0xe0, 5, jjupysshyxnm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 6, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd mmxwrbegvhif = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, ontgfftakrct }, { 1, 2, 0x07, 0, fsrpwjnnruda }, { 1, 8, 0x18, 3, uwfodcrrykio }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd yqccrlbjtier = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 120, {24, 96, 0, 0}, { 1, 2, 0xf0, 4, ontgfftakrct }, { 1, 2, 0x07, 0, fsrpwjnnruda }, { 1, 8, 0x18, 3, uwfodcrrykio }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd bchfpzjwyyzq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, skkuscfhnkez }, { 0x80, 0, 0x0c, 2, ppqwlkzsrggl }, { 0, 0, 0x30, 4, zveummuuqpoh }, { 0, 4, 0x20, 5, uddchsavduck }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ugeujihichum, NULL };
static const struct gpbqxitaiizd uubylrhxqdjv = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 84, {24, 56, 4, 0}, { 1, 1, 0xf0, 4, skkuscfhnkez }, { 1, 0, 0xe0, 5, rbqteagsldzp }, { 1, 2, 0x70, 4, kfiokuecrvod }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, hcghivuzrpmj, NULL };
static const struct gpbqxitaiizd hxqywwrxcpad = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {24, 64, 0, 0}, { 1, 6, 0xf0, 4, ontgfftakrct }, { 1, 6, 0x07, 0, fsrpwjnnruda }, { 1, 4, 0xe0, 5, jjupysshyxnm }, { 0, 0, 0, 0, NULL }, &btskbanpruvy, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 6, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd heohynfatxwl = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, ontgfftakrct }, { 0x0, 4, 0x07, 0, fsrpwjnnruda }, { 0, 2, 0x70, 4, hiiobvtytlxu }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0,3},4,0x08}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd cqbxzirerlcz = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 152, {24, 128, 0, 0}, { 1, 4, 0x0f, 0, ontgfftakrct }, { 1, 2, 0x07, 0, fsrpwjnnruda }, { 1, 6, 0x07, 0, qrxesvjaizkd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd wtcwfdjkglbn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 128, {128, 0, 0, 0}, { 0, 6, 0x3e, 1, tzobemjbbfwa }, { 0, 5, 0xc0, 6, buvyfaternak }, { 0, 5, 0x0c, 2, eerwapzvukix }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lnctpfcenogx, NULL };
static const struct gpbqxitaiizd npvlvjeskbjp = { {0, 1, 0, 0 ,0, 0, 0}, 0x31, 96, {32, 32, 32, 0}, { 0, 0, 0x0f, 0, tsdmfgpfasfa }, { 0, 2, 0x07, 0, amjlwwtuumqb }, { 0, 0, 0x70, 4, zqtslcvzjlbs }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, gjxebyvdvqox, NULL };
static const struct gpbqxitaiizd xctmfwosqadw = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x3e, 1, rrdygacrtxau }, { 1, 7, 0x70, 4, xmmbocarwnfb }, { 1, 11, 0x70, 4, xmpbznnszzgm }, { 1, 6, 0x04, 2, ogkmhkfakteu }, &pikumtrjbono, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 7, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd gpstnahujjjt = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 6, 0x3e, 1, tzobemjbbfwa }, { 0, 5, 0xe0, 5, lgzqftmoksec }, { 0, 5, 0x0e, 1, ixdmyrsxsnwd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, joaemonkmxrp, &ltbihlmrbgbz };
static const struct gpbqxitaiizd mahotgxpafpn = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, cmntsrwmylfh }, { 1, 4, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.lztusevbiwbk = (bc7215DataVarPkt_t*)ryokukpjfgch}, kbrdlavnrake, &icccxsqevewz };
static const struct gpbqxitaiizd ihftwtmjokcy = { {0, 1, 1, 0, 0, 0, 0}, 0x31, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.lztusevbiwbk = (bc7215DataVarPkt_t*)lufulicjnyck}, vehpzgezvach, &wjzlthcmibqi };
static const struct gpbqxitaiizd ugsyfeiousgk = { {0, 1, 1, 0, 0, 0, 0}, 0x36, 112, {12, 44, 12, 44}, { 3, 3, 0x0f, 0, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.lztusevbiwbk = (bc7215DataVarPkt_t*)uuglrllwxjhy}, vehpzgezvach, &wjzlthcmibqi };
static const struct gpbqxitaiizd xqtvuyolcfqv = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 44, 13, 44}, { 3, 3, 0x1e, 1, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.lztusevbiwbk = (bc7215DataVarPkt_t*)uuglrllwxjhy}, sifulwqeulvu, &fkcfehqixyem };
static const struct gpbqxitaiizd ogophkvjgbgq = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF0, 4, cmntsrwmylfh }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)nwjarwwisfjy}, rfuodgfprtbp, &ozrsiabmdpow };
static const struct gpbqxitaiizd rqblscbetsku = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, cmntsrwmylfh }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)sppjsrhnokms}, rfuodgfprtbp, &ozrsiabmdpow };
static const struct gpbqxitaiizd uqfrdcijahbn = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, cmntsrwmylfh }, { 0, 4, 0x07, 0, vfrrxicjjbuw }, { 0, 4, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)hqwmeruostxl}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd cwnyaweelauk = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 3, 0xF0, 4, cmntsrwmylfh }, { 0, 4, 0x0f, 0, cuschsbgglyo }, { 0, 4, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)hqwmeruostxl}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd veppqzgkcwxa = { {0, 1, 0, 0, 0, 1, 0}, 0x34, 104, {40, 64, 0, 0}, { 1, 1, 0xfe, 1, duwlxejfbcur }, { 1, 0, 0x0f, 0, bqvhwdgpcegx }, { 1, 0, 0x70, 4, kuwjmesodnrm }, { 0, 0, 0, 0, NULL }, &qwdcybrpkpwf, {.gecmoisvuikh.lnrpcoyamxnd= {{1, 3}, 6, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, hcghivuzrpmj, NULL };
static const struct gpbqxitaiizd owyrjknhibbq = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 144, {56, 88, 0, 0}, { 1, 1, 0xF8, 3, ytbrcludyvxf }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x0f, 0, bptiyeqxsrnd }, { 1, 1, 0x01, 0, ogkmhkfakteu }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)embnmdrdqphz}, rfuodgfprtbp, NULL };
static const struct gpbqxitaiizd ulclftuloupl = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 264, {56, 208, 0, 0}, { 1, 1, 0xF8, 3, ytbrcludyvxf }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x0f, 0, bptiyeqxsrnd }, { 1, 1, 0x01, 0, ogkmhkfakteu }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)wgniorglrypz}, rfuodgfprtbp, NULL };
static const struct gpbqxitaiizd tjbckkvfmuzc = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 3, 0xFF, 0, ypgweitsalat }, { 0, 1, 0x0f, 0, xrtmtnnigcml }, { 0, 1, 0xf0, 4, rgospvmfksfb }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 4, 0x40}}, eiwjvqfivinv, NULL };
static const struct gpbqxitaiizd jqfxvdaldqti = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xF8, 3, ytbrcludyvxf }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)nwjarwwisfjy}, rfuodgfprtbp, NULL };
static const struct gpbqxitaiizd kixkachqhgxm = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 264, {24, 240, 0, 0}, { 1, 10, 0x3c, 2, cmntsrwmylfh }, { 1, 22, 0x07, 0, jqhzoursarms }, { 1, 22, 0x70, 4, kgpncohttvpp }, { 1, 8, 0xff, 0, yoanurqmkmwa }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 24, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, eywapiiglxig, NULL };
static const struct gpbqxitaiizd qlkwsplmlxxu = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 344, {24, 320, 0, 0}, { 1, 10, 0x3c, 2, cmntsrwmylfh }, { 1, 22, 0x07, 0, jqhzoursarms }, { 1, 22, 0x70, 4, kgpncohttvpp }, { 1, 8, 0xff, 0, yoanurqmkmwa }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 24, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, eywapiiglxig, NULL };
static const struct gpbqxitaiizd iinauwztyhtq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 224, {56, 168, 0, 0}, { 1, 4, 0x3e, 1, sknaonxhcbby }, { 1, 3, 0x0f, 0, kqmuudzshyev }, { 1, 6, 0x07, 0, qlyufofbkekd }, { 1, 2, 0x0f, 0, shlehzkvxzjx }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 10, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ibemvitqxulw, &ljqcvrliuqjk };
static const struct gpbqxitaiizd giltllkqimaq = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 296, {24, 272, 0, 0}, { 1, 10, 0x3c, 2, cmntsrwmylfh }, { 1, 22, 0x0f, 0, vmmjkuxiguyg }, { 1, 22, 0x70, 4, oxczxmxtlfvg }, { 1, 8, 0xff, 0, yoanurqmkmwa }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 24, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, eywapiiglxig, NULL };
static const struct gpbqxitaiizd ftxxqmbjjsdi = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 40, {40, 0, 0, 0}, { 0, 3, 0x0f, 0, skkuscfhnkez }, { 0, 2, 0x07, 0, ybmndoxkcgvq }, { 0, 2, 0x70, 4, hiiobvtytlxu }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, nxxkpocakeer, NULL };
static const struct gpbqxitaiizd rhkkgxcgdszi = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0, 4, 0x70, 4, jppjhqlrjxqz }, { 0, 4, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 5, 0x41}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd opwkbtmblfkk = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, sknaonxhcbby }, { 2, 5, 0x70, 4, oprimmhycskq }, { 2, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &ehbtnshbflmy, {.gecmoisvuikh.lnrpcoyamxnd = {{2, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{1, 3}, 11, 0x80}}, mrvqonwscbcw, &dpfoulglkedq };
static const struct gpbqxitaiizd mxpgyiwrgzls = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 200, {56, 144, 0, 0}, { 1, 10, 0x3e, 1, rrdygacrtxau }, { 1, 7, 0x70, 4, gfyccfwkubos }, { 1, 11, 0x70, 4, xmpbznnszzgm }, { 1, 6, 0x04, 2, ogkmhkfakteu }, &okxbejklxnat, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 7, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{1, 9}, 6, 0x04}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd zzzalzebsece = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 157, {5, 152, 0, 0}, { 1, 6, 0xfe, 1, sknaonxhcbby }, { 1, 5, 0x70, 4, oprimmhycskq }, { 1, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, &xvbyrkpbudok };
static const struct gpbqxitaiizd fweqefxyrayk = { {0, 1, 0, 0, 0, 1, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, cmntsrwmylfh }, { 0x00, 2, 0x07, 0, amjlwwtuumqb }, { 0, 0, 0xf0, 4, zqtslcvzjlbs }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, clckwhrtozge, NULL };
static const struct gpbqxitaiizd febqygkpducf = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, ypgweitsalat }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kkrphttycecy, NULL };
static const struct gpbqxitaiizd clkpqifqojxx = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 286, {6, 64, 64, 152}, { 3, 6, 0xfe, 1, sknaonxhcbby }, { 3, 5, 0x70, 4, oprimmhycskq }, { 3, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &ugjpaihlyruf, {.gecmoisvuikh.lnrpcoyamxnd = {{3, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ffcmssmueytf, &fgzixfgwbxdg };
static const struct gpbqxitaiizd czzugxbmrwat = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 4, 0x0f, 0, cmntsrwmylfh }, { 0, 1, 0x70, 4, gsgvhxtxcjom }, { 0, 5, 0xe0, 5, dgaywuihyxnp }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, pgkfblaqcowv, NULL };
static const struct gpbqxitaiizd xhfhwwdgvvov = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 96, {32, 32, 32, 0}, { 0, 2, 0xf0, 4, quywhrfyrrqx }, { 0xC0, 3, 0x0f, 0, clxbgiliwlkd }, { 0x40, 4, 0x0f, 0, nvjodrzzlddk }, { 0, 4, 0xff, 0, eldhmgwhdxql }, &zuaxiuysvzqe, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, gosteyduspss, NULL };
static const struct gpbqxitaiizd fsprzrcpusot = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, cmntsrwmylfh }, { 0, 9, 0xe0, 5, oqmqtbrtarwr }, { 0, 7, 0x60, 5, zveummuuqpoh }, { 0, 5, 0x1f, 0, gfrivhrrckkq }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 7, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, czblcwvndhot, NULL };
static const struct gpbqxitaiizd ltqjpfleahgl = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0, 5, 0x70, 4, qluwdrmtlnbc }, { 0, 4, 0x07, 0, cfxbmslkginh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 0, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd berhuoftzatq = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, ypgweitsalat }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, rgospvmfksfb }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, bjxkhzdelqda, NULL };
static const struct gpbqxitaiizd jnnjlqttaawt = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0x80, 1, 0xc0, 6, dbffjkhqcczz }, { 0, 1, 0x30, 4, zveummuuqpoh }, { 0, 4, 0x02, 1, opbubkswvgez }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd sdcxqlaqrbze = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 128, {72, 56, 0, 0}, { 0, 6, 0xFF, 0, cxsrtekxdzqc }, { 0, 1, 0x0f, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, kaoazvneauzk, NULL };
static const struct gpbqxitaiizd ljchafgodnoy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 2, 0xf0, 4, cmntsrwmylfh }, { 0xC0, 3, 0x0f, 0, makhjmseykqq }, { 0x40, 4, 0x0f, 0, nvjodrzzlddk }, { 0, 4, 0xff, 0, eldhmgwhdxql }, &hwmmdrygbfas, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 2, 0x85}, .gecmoisvuikh.aqpwroyoznxu = {{0,8},3,0x16}}, lcwkklzlvqfk, NULL };
static const struct gpbqxitaiizd mugvzitdydws = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xff, 0, ypgweitsalat }, { 0, 2, 0x07, 0, lmlgvjpkpdnq }, { 0, 2, 0x60, 5, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 1, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, czblcwvndhot, NULL };
static const struct gpbqxitaiizd edjdozslltkq = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, cmntsrwmylfh }, { 0, 6, 0x70, 4, oqmqtbrtarwr }, { 0, 6, 0x03, 0, llwlyvriyeuj }, { 0, 0, 0, 0, NULL }, &hwdkadparycc, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, czblcwvndhot, NULL };
static const struct gpbqxitaiizd trbwaneynklu = { {1, 0, 0, 1, 1, 0, 0}, 0x35, 100, {100, 0, 0, 0}, { 0, 3, 0x0F, 0, cmntsrwmylfh }, { 0, 4, 0x07, 0, qaekeemfcech }, { 0, 4, 0x70, 4, fwzhjkcbkbzj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd svknsbjhsqkr = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x0f, 0, cmntsrwmylfh }, { 0, 9, 0xe0, 5, oqmqtbrtarwr }, { 0, 7, 0xe0, 5, zveummuuqpoh }, { 0, 5, 0xff, 0, gfrivhrrckkq }, &uytamwzgxgtg, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 7, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, uohctvovsvci, NULL };
static const struct gpbqxitaiizd uolpkicrjvas = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 192, {16, 80, 16, 80}, { 1, 0, 0xf0, 4, cmntsrwmylfh }, { 1, 0, 0x07, 0, ozcvxzcbzysd }, { 1, 8, 0xf0, 4, kbeiscfdapob }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 8}, 0, 0x82}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, nfsmzyppyfrp, NULL };
static const struct rsvujpsrigrz biyiikwonuqe = {NULL, &uolpkicrjvas, 1, 95};
static const struct gpbqxitaiizd gzyabegxxfux = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 96, {16, 80, 0, 0}, { 1, 0, 0xf0, 4, cmntsrwmylfh }, { 1, 0, 0x07, 0, ozcvxzcbzysd }, { 1, 8, 0xf0, 4, kbeiscfdapob }, { 0x80, 0, 0, 0, NULL }, &rxawcdbrablz, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 8}, 0, 0x82}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, hcghivuzrpmj, NULL };
static const struct gpbqxitaiizd pwmpntwzcyrs = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, tahpslefwigh}, { 0, 6, 0x0f, 0, ocakliobujtr}, { 0, 8, 0x07, 0, kfiokuecrvod}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd tvkapeulemxo = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 136, {136, 0, 0, 0}, { 0, 0x46, 0xFF, 0, lkcleczckmqs }, { 0x0, 5, 0xf0, 4, rgwtgswgpuya }, { 0, 5, 0x0f, 0, onpxavfvifmb }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 8, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, vsjfqnukiezq, NULL };
static const struct gpbqxitaiizd zdhnvgegjmok = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 3, 0xf0, 4, cmntsrwmylfh }, { 0, 3, 0x07, 0, glchtfgsebbd }, { 0, 2, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,8}, 2, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd gwkpmwlueund = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, cmntsrwmylfh }, { 0, 0, 0x8C, 2, egtqmfwlmndn }, { 0, 0, 0x03, 0, uwfodcrrykio }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,8}, 1, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, malrkmeqrwmb, NULL };
static const struct gpbqxitaiizd kawrmqcxefrq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 47, {47, 0, 0, 0}, { 0, 5, 0x1F, 0, ontgfftakrct }, { 0, 2, 0x0C, 2, cjwtggkjrket }, { 0, 2, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9}, 1, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd wonnolwwyjoi = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 30, {7, 8, 7, 8}, { 1, 0, 0x0F, 0, iflsbfgramhw }, { 0, 0, 0x07, 0, lgzqftmoksec }, { 0, 0, 0x70, 4, zwpdmgxmjngn }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,8}, 0, 0x35}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, zojrkykrpxnk, NULL };
static const struct gpbqxitaiizd pqvlccdogfop = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0F, 0, cmntsrwmylfh }, { 0, 1, 0x30, 4, dpassarelhfz }, { 0, 1, 0xc0, 6, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,8}, 1, 0x0c}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd krppsvwkmxuy = { {1, 1, 1, 0, 0, 0, 0}, 0x32, 192, {48, 48, 48, 48}, { 0, 4, 0xf0, 4, cjspeajeetae }, { 0x00, 4, 0x0c, 2, dvpuldozuwvu }, { 0x80, 2, 0xe0, 5, wqcopogbpbpz }, { 2, 2, 0xff, 0, imhhvyymfnup }, &bulclcezozas, {.lztusevbiwbk = (const bc7215DataVarPkt_t*)qixkoejkuics}, bjtkknsuuyti, NULL };
static const struct gpbqxitaiizd epepleuvkqmw = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 368, {64, 152, 152, 0}, { 1, 6, 0x1e, 1, cmntsrwmylfh }, { 1, 5, 0x70, 4, oprimmhycskq }, { 1, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, plljdoetcfhs, NULL };
static const struct gpbqxitaiizd tvewknkkdxpn = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 40, {32, 8, 0, 0}, { 0, 2, 0x0F, 0, cmntsrwmylfh }, { 0, 1, 0x07, 0, oqmqtbrtarwr }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,3}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, fvzpivxekuqk, NULL };
static const struct gpbqxitaiizd kgejskcuvuor = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 168, {16, 96,56, 0}, { 1, 1, 0xf0, 4, cmntsrwmylfh }, { 1, 1, 0x07, 0, glchtfgsebbd }, { 1, 0, 0x03, 0, zveummuuqpoh }, { 2, 1, 0xff, 0, cgirezmuuzsl }, &wdolqoxxzcjd, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 0, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bgzdumfejgds, &lclohufezpej };
static const struct gpbqxitaiizd gntgkjyewxko = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, ypgweitsalat }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bjxkhzdelqda, &svnlxylljumb };
static const struct gpbqxitaiizd fsaaejorraxh = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 97, {96, 1, 0, 0}, { 0, 1, 0x0F, 0, cmntsrwmylfh }, { 0, 4, 0x70, 4, jppjhqlrjxqz }, { 0, 4, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 5, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd rfprlrerbift = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0x0F, 0, tsdmfgpfasfa }, { 0, 0, 0x07, 0, suqrsgzbyjrl }, { 0, 0, 0xf0, 4, kbeiscfdapob }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, malrkmeqrwmb, NULL };
static const struct gpbqxitaiizd lriwksytvocn = { {0, 0, 0, 0, 0, 1, 0}, 0x36, 140, {140, 0, 0, 0}, { 0, 16, 0xff, 0, ypgweitsalat }, { 0, 15, 0x70, 4, kuduzvpllyzr }, { 0, 15, 0x0f, 0, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,3}, 14, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ciqwjzqbjrek, NULL };
static const struct gpbqxitaiizd bwupnkcrkiqs = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 5, 0xf0, 4, tsdmfgpfasfa }, { 0, 4, 0x70, 4, zxtkmrtwpcwq }, { 0, 4, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9}, 4, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ivuepqetauuu, NULL };
static const struct gpbqxitaiizd frjonxghfyhr = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {31, 31, 0, 0}, { 0, 3, 0x1e, 1, ontgfftakrct }, { 0, 0, 0xf0, 4, kobtotblliyt }, { 0, 1, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 1, 0x20}}, ugeujihichum, NULL };
static const struct gpbqxitaiizd iocpxioxgwiv = { {0, 1, 0, 1, 1, 1, 0}, 0x36, 262, {64, 64, 0, 0}, { 0, 6, 0xFF, 0, ypgweitsalat }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{1, 3}, 2, 0x04}}, giyhkblgxico, &dcwqifidhzed };
static const struct gpbqxitaiizd bykcxrhccvkw = { {0, 1, 0, 0, 0, 0, 0}, 0x35, 201, {35,67,67,32}, { 0, 1, 0x0f, 0, cmntsrwmylfh }, { 0, 0, 0x07, 0, oqmqtbrtarwr }, { 0x82, 2, 0x70, 4, xmpbznnszzgm }, { 0, 0, 0x30, 4, tgtfklffchvs }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, gyvkurmqtjgv, NULL };
static const struct gpbqxitaiizd kbxtedwgjrxl = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x7f, 0, ervibksmelem }, { 0, 1, 0x70, 4, xbhgwzixmpds }, { 0, 7, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk=(const bc7215DataVarPkt_t*)jxljgfhervmx}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd mupcowuytnbo = { {0, 1, 0, 0, 0, 0, 1}, 0x34, 95, {22, 60, 8, 5}, { 1, 0, 0x1f, 0, tzobemjbbfwa }, { 0, 2, 0x38, 3, acrfzoslpxvx }, { 1, 0, 0x60, 5, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &qjqyhmworaxm, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 6, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, tlssicamrhrl, NULL };
static const struct gpbqxitaiizd zlkkibrhxpkb = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 2, 0x1f, 0, tzobemjbbfwa }, { 0, 1, 0xE0, 5, asearepltykx }, { 0, 2, 0xe0, 5, yvgjmdzgltwv }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 3, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd gjsqihzgltcg = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 72, {16, 56, 0, 0}, { 1, 1, 0x0f, 0, furrpwcvfmwl }, { 1, 0, 0x07, 0, gujgntlkisyx }, { 1, 0, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd gbkrozbbniqv = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 1, 0xF0, 4, cmntsrwmylfh }, { 0, 6, 0x07, 0, gujgntlkisyx }, { 0, 6, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &kqdefetwjhjv };
static const struct gpbqxitaiizd yaacbidcxqab = { {1, 1, 0, 0, 0, 0, 0}, 0x32, 256, {72, 72, 56, 56}, { 0, 5, 0xF0, 4, uwhhynzlqhub }, { 0, 6, 0x07, 0, lmlgvjpkpdnq }, { 0, 6, 0xe0, 5, kqxvuienezqh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x07}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ekerqtujxlsh, NULL };
static const struct gpbqxitaiizd fhumgzymonvx = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x0f, 0, uwhhynzlqhub }, { 0, 1, 0x07, 0, oyapdunuwhxp }, { 0, 1, 0x18, 3, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, tepikmqypoha, NULL };
static const struct gpbqxitaiizd rvfxcklyarhc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 2, 0x07, 0, oqmqtbrtarwr }, { 0, 2, 0x70, 4, xmpbznnszzgm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, wsbjubuhhksr, NULL };
static const struct gpbqxitaiizd ukhmrhdyenqc = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 2, 0x07, 0, oqmqtbrtarwr }, { 0, 2, 0x70, 4, xmpbznnszzgm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, sptnttmtlvun, NULL };
static const struct gpbqxitaiizd vgkzjjlggisn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, uwhhynzlqhub }, { 0, 6, 0x07, 0, buvyfaternak }, { 0, 6, 0x70, 4, pozadfedxavz }, { 0, 5, 0x30, 4, amqbadksuqji }, &wwdcudhjbcjc, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kxuqubvzffbt, NULL };
static const struct gpbqxitaiizd bapantvdsdcw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x1e, 1, pzskpnrdiidk }, { 0, 6, 0x0f, 0, aqppyhghhlof }, { 0, 6, 0x70, 4, pozadfedxavz }, { 0, 5, 0x30, 4, amqbadksuqji }, &wwdcudhjbcjc, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kxuqubvzffbt, &hfosnmdagufh };
static const struct gpbqxitaiizd bgwxvfffawil = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 4, 0x0f, 0, tsdmfgpfasfa }, { 0, 6, 0x07, 0, buvyfaternak }, { 0, 6, 0x70, 4, pozadfedxavz }, { 0, 5, 0x30, 4, amqbadksuqji }, &fvjvlzkzeava, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kxuqubvzffbt, NULL };
static const struct gpbqxitaiizd xwxoyewoqbkk = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 96, {32, 32, 32, 0}, { 1, 1, 0xf0, 4, uwhhynzlqhub }, { 1, 1, 0x07, 0, buvyfaternak }, { 1, 2, 0x70, 4, xmpbznnszzgm }, { 1, 3, 0x03, 0, amqbadksuqji }, &cxwhixryrtfz, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, gmvsypoheoui, NULL };
static const struct gpbqxitaiizd wvivwpzlmjfj = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 44, {44, 0, 0, 0}, { 0, 1, 0xF0, 4, ashsyhfolavx }, { 0, 0, 0xe0, 5, dhyevkwmtrkz }, { 0, 0, 0x0c, 2, lxfkqoyuzihi }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0,8}, 0, 0x00}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd kkemsewtocsm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0, 3, 0x0e, 1, njxjmutvixzc }, { 0, 6, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 3, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd mlwazxtpyxam = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, fvzpivxekuqk, NULL };
static const struct gpbqxitaiizd pzndabqqnhip = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0xff, 0, ypgweitsalat }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd qfglwecimhwj = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 64, {32, 32, 0, 0}, { 0, 0, 0x0f, 0, tsdmfgpfasfa }, { 0, 2, 0x07, 0, srhimdmxtgvx }, { 0, 0, 0xf0, 4, rgospvmfksfb }, { 0, 0, 0, 0, NULL }, &yexwjtvednlb, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, dzjaxehfbhfv, NULL };
static const struct gpbqxitaiizd vyvkvtvzvkot = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, tsdmfgpfasfa }, { 0, 3, 0x07, 0, vucznueqscto }, { 0, 3, 0x70, 4, vhmperrnwyuc }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 2, 0xb8}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, fwseuthvpykb, NULL };
static const struct gpbqxitaiizd mespjqfkaxfx = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0, 2, 0xe0, 5, oqmqtbrtarwr }, { 0, 5, 0x60, 5, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, gmefryrjqpxw, NULL };
static const struct gpbqxitaiizd mupchketvfjs = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 312, {160, 152, 0, 0}, { 1, 6, 0xfe, 1, sknaonxhcbby }, { 1, 5, 0x70, 4, oprimmhycskq }, { 1, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &nbtqmbshmoln, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{1, 9}, 5, 0x01}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd yekdcttxuoou = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 160, {56, 104, 0, 0}, { 1, 9, 0x3E, 1, rrdygacrtxau }, { 1, 5, 0x70, 4, hhtcymniazqt }, { 1, 10, 0x0f, 0, cxneheyfiqpy }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd utortrgmqnpi = { {0, 1, 0, 0, 0, 0, 0}, 0x32, 128, {32, 32, 32, 32}, { 0, 0x0, 0x0f, 0, tsdmfgpfasfa }, { 0x00, 2, 0x07, 0, wvxudbqtvdqv }, { 0, 0, 0xf0, 4, zqtslcvzjlbs }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, clckwhrtozge, NULL };
static const struct gpbqxitaiizd lrvkaxmbbuxk = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 84, {84, 0, 0, 0}, { 0, 1, 0xff, 0, ldcsxehevkyw }, { 0x00, 0, 0x07, 0, oqmqtbrtarwr }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &zkpwghmcxqkx, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd gedgfkrqvtpt = { {0, 0, 0, 0, 0, 0, 0}, 0x36, 72, {72, 0, 0, 0}, { 0, 6, 0xff, 0, cxsrtekxdzqc }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, bjxkhzdelqda, NULL };
static const struct gpbqxitaiizd kekcwozbekyv = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 3, 0x30, 4, qnmyddjmgedp }, { 0, 3, 0x03, 0, eerwapzvukix }, { 0, 2, 0xff, 0, sfogdqkjwmyz }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)sxthzfmpbrjb }, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd nfofbpdpsajo = { {0, 0, 1, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0x80, 3, 0x30, 4, qnmyddjmgedp }, { 0, 3, 0x03, 0, eerwapzvukix }, { 0, 2, 0xff, 0, zcnokhwhweyw }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)erkbbiwelcmy }, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd esbudowscame = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 4, 0x0f, 0, gcajumhjzbzp }, { 0, 4, 0x30, 4, ojeoftlzgpeq }, { 0, 2, 0x07, 0, sndrvydgwxhi }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 4, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd hirxzplccxcl = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0x0f, 0, ontgfftakrct }, { 0, 4, 0x18, 3, bbmoirnyyvpa }, { 0, 4, 0x07, 0, gmcoqyvowqls }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 3}, 4, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd kqpaqebllmpv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct }, { 0, 2, 0x07, 0, wrrnxlvsulqv }, { 0, 0, 0x18, 3, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd bzsxihoogbiq = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 80, {80, 0, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct }, { 0, 2, 0x03, 0, bbmoirnyyvpa }, { 0, 0, 0x18, 3, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd msqeuttrvezv = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 64, {64, 0, 0, 0}, { 0, 4, 0xf0, 4, ontgfftakrct }, { 0x0, 4, 0x07, 0, fsrpwjnnruda }, { 0, 2, 0x70, 4, gmcoqyvowqls }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0,3},4,0x08}}, ksntmuuzguel, NULL };
static const struct gpbqxitaiizd gvpslonsorlw = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 64, {32, 32, 0, 0}, { 0, 2, 0x0f, 0, uwhhynzlqhub }, { 0x0, 2, 0x70, 4, ycdmpncfihnp }, { 0, 1, 0x70, 4, wnncwqsqsynw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, hojheepfghni, NULL };
static const struct gpbqxitaiizd znclkdnjtoqp = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 152, {152, 0, 0, 0}, { 0, 6, 0x3e, 1, tzobemjbbfwa }, { 0x80, 5, 0xe0, 5, lgzqftmoksec }, { 0, 5, 0x0c, 2, eerwapzvukix }, { 0, 6, 0x80, 7, opbubkswvgez }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 8, 0x20}}, vhutgysqfljg, &volufrrpyips };
static const struct gpbqxitaiizd qawblprzgjnv = { {0, 1, 1, 0, 0, 0, 0}, 0x37, 113, {12, 45, 12, 44}, { 3, 3, 0x0f, 0, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.lztusevbiwbk = (bc7215DataVarPkt_t*)uuglrllwxjhy}, vehpzgezvach, NULL };
static const struct gpbqxitaiizd mdmlqsyyarjs = { {1, 1, 1, 0 , 0, 0, 0}, 0x36, 160, {80, 80, 0, 0}, { 0, 5, 0xf0, 4, uwhhynzlqhub}, { 0, 6, 0x07, 0, lmlgvjpkpdnq}, { 0, 6, 0xC0, 6, ympjwtujtzjj }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)igcwaisxjzoc}, wgxxnrxllosg, NULL };
static const struct gpbqxitaiizd isedljrkknwe = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 1, 0x0f, 0, promikpkgqdf }, { 0, 1, 0xe0, 5, fxrzumoltkin }, { 0, 6, 0x1f, 0, njkrlbejkiyx }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd lcvluxgkpxuf = { {0, 1, 1, 0, 0, 0, 0}, 0x32, 192, {96, 48, 48, 0}, { 1, 4, 0x0f, 0, gcajumhjzbzp }, { 1, 4, 0x30, 4, ojeoftlzgpeq }, { 1, 2, 0x07, 0, sndrvydgwxhi }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.lztusevbiwbk = (const bc7215DataVarPkt_t*)odprdqbfxjko}, wdiwmiuvusjg, NULL };
static const struct gpbqxitaiizd unobicdrwlcp = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 161, {56, 104, 1, 0}, { 1, 9, 0xFE, 1, pzskpnrdiidk }, { 1, 5, 0x70, 4, hhtcymniazqt }, { 1, 10, 0x0f, 0, cxneheyfiqpy }, { 0, 0, 0, 0, NULL}, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, NULL };
static const struct gpbqxitaiizd tsjnrjaxikkw = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0x0, 5, 0x70, 4, llwlyvriyeuj }, { 0, 4, 0x07, 0, wzkubwkdaosj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd hizekitbfwzc = { {1, 0, 0, 0, 0, 0, 0}, 0x36, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0x40, 5, 0xf0, 4, krpfaigmnlww }, { 0, 5, 0xf0, 4, pcqdqyashrim }, { 0, 0, 0, 0, NULL }, &hbcwtlayojwf, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 0, 0x80}}, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd upmtgbvymhaf = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0x40, 5, 0xf0, 4, krpfaigmnlww }, { 0, 5, 0xf0, 4, pcqdqyashrim }, { 0, 0, 0, 0, NULL }, &hbcwtlayojwf, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 0, 0x80}}, jtjaworrdkzn, NULL };
static const struct rsvujpsrigrz epsqsvzmjoij = {NULL, &erpekfehcrhs, 2, 165};
static const struct gpbqxitaiizd cbdugghduwib = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, kuyqbnkbyxpc }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0x80, 2, 0x0f, 0, xcjqyivqssjo }, &yhtmypmhossg, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,9},0,0x10}}, ndnhvunsikoa, NULL };
static const struct rsvujpsrigrz irxydjyuqjfh = {NULL, &zsfkmkycjmkh, 2, 165};
static const struct gpbqxitaiizd dlchrrirbmpe = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, oqkgqijxnddh }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0x80, 2, 0x0f, 0, hghxsrwbzetq }, &umtzlcknmpju, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,9},0,0x10}}, ndnhvunsikoa, NULL };
static const struct rsvujpsrigrz cvpvnunedldm = {NULL, &gkbppxpzkaye, 2, 165};
static const struct gpbqxitaiizd gqjabkprnssk = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, oqkgqijxnddh }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0x80, 2, 0x0f, 0, xcjqyivqssjo }, &qcfrsqpvdsul, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,9},0,0x10}}, ndnhvunsikoa, NULL };
static const struct rsvujpsrigrz vveskdcbytgr = {NULL, &ydjjygjuwvjw, 2, 165};
static const struct gpbqxitaiizd gxkkbcqmavdb = { {0, 0, 0, 0, 0, 0, 0}, 0x35, 20, {20, 0, 0, 0}, { 0, 0x1, 0x0f, 0, tpncdzkkpnwf }, { 0x00, 1, 0x30, 4, cugupfctjayw }, { 0, 1, 0xc0, 6, zoftehwidnrp }, { 0x80, 2, 0x0f, 0, hghxsrwbzetq }, &vxemyucvhvvc, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,9},0,0x10}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd pkjoeazqzgyn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, jklpqvoiftkz }, { 0xc0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, joiqzgqdrshc, NULL };
static const struct gpbqxitaiizd rfkrcbneoyrv = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, NULL}, { 0x40, 0, 0, 0, gktarqxjpekq }, { 0xc0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, litmtotzgcwv, NULL };
static const struct gpbqxitaiizd zufkkpgwjjqz = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 1, 0xF0, 4, xgwistjfovfg }, { 0, 1, 0x0F, 0, rgospvmfksfb }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 2, 0X01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd tekorjstpjbp = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 104, {24, 80, 0, 0}, { 1, 2, 0xf0, 4, ontgfftakrct }, { 1, 2, 0x07, 0, fsrpwjnnruda }, { 1, 4, 0xe0, 5, ycawfkzekccz }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 3}, 2, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd dagrouszppkl = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, quywhrfyrrqx }, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd ofwkiawyjfsq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 0, 0x30, 4, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd onhvchrojvab = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 144, {16, 56, 16, 56}, { 1, 3, 0xf0, 4, cmntsrwmylfh }, { 1, 0, 0xF0, 4, etiaceogyvvv }, { 1, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0Xf0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, fwtvtkvhxwyl, NULL };
static const struct gpbqxitaiizd yhxrtikljxhy = { {1, 1, 0, 0, 0, 0, 0}, 0x30, 160, {16, 64, 16, 64}, { 1, 3, 0xf0, 4, cmntsrwmylfh }, { 1, 0, 0xF0, 4, etiaceogyvvv }, { 1, 1, 0x30, 4, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0Xf0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, fwtvtkvhxwyl, NULL };
static const struct gpbqxitaiizd ujkgzmselnra = { {0, 1, 0, 0, 0, 1, 0}, 0x37, 48, {24, 24, 0, 0}, { 0, 2, 0x0f, 0, quywhrfyrrqx }, { 0, 2, 0x70, 4, ycdmpncfihnp }, { 0, 1, 0x70, 4, fwzhjkcbkbzj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 2, 0xa7}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, hojheepfghni, NULL };
static const struct gpbqxitaiizd zydrksiyikcq = { {0, 1, 0, 0, 0, 1, 0}, 0x21, 102, {34, 34, 34, 0}, { 0, 1, 0x1E, 1, tsdmfgpfasfa }, { 0, 0, 0x70, 4, juzymymxyjcf }, { 0, 0, 0x0c, 2, hbkwawzvifnd }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 8}, 0, 0x9c}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, cudbvananeib, NULL };
static const struct gpbqxitaiizd dpndrhztsnad = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 100, {50, 50, 0, 0}, { 0, 3, 0x78, 3, ontgfftakrct }, { 0x80, 0, 0x0c, 2, iexxstwfurfd }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 4, 0xff, 0, agktjmrthdnf }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 9}, 5, 0x30}}, ugeujihichum, NULL };
static const struct gpbqxitaiizd npzwquhpbdgo = { {0, 0, 0, 0, 0, 1, 0}, 0x30, 64, {64, 0, 0, 0}, { 0, 6, 0xFF, 0, ypgweitsalat }, { 0, 1, 0x0F, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bjxkhzdelqda, &svnlxylljumb };
static const struct gpbqxitaiizd fvjztvgjvdvh = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 112, {112, 0, 0, 0}, { 0, 7, 0x0f, 0, skkuscfhnkez}, { 0, 6, 0x0f, 0, jnioisscmtak}, { 0, 8, 0x07, 0, jfmsxunfkwnt }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd ovzoqhjyriyc = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 17, {16, 1, 0, 0}, { 0, 1, 0xF8, 3, xorskegihgke }, { 0, 1, 0x07, 0, oqmqtbrtarwr }, { 0, 0, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 0, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, aaqdnsdafnoh, NULL };
static const struct gpbqxitaiizd lkxubfnzxtll = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 5, 0x0f, 0, tsdmfgpfasfa }, { 0, 4, 0x70, 4, oqmqtbrtarwr }, { 0, 4, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 3, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, iczmyxkcwwqr, NULL };
static const struct gpbqxitaiizd fzqptiluekii = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 144, {48, 48, 48, 0}, { 0, 2, 0xf0, 4, quywhrfyrrqx }, { 0, 3, 0x07, 0, njxjmutvixzc }, { 0, 3, 0x70, 4, vhmperrnwyuc }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, wmyhhyzoejor, NULL };
static const struct gpbqxitaiizd bhetectmiqcj = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 35, {35,0,0,0}, { 0, 1, 0x0f, 0, cmntsrwmylfh}, { 0, 0, 0x07, 0, oqmqtbrtarwr}, { 0, 3, 0x03, 0, nvjodrzzlddk}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd txhetlrkjejm = { {1, 1, 0, 0, 0, 0, 0}, 0x37, 176, {112, 64, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &tvgeaystgvul, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd npffcbnscufi = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x0f, 0, cmntsrwmylfh }, { 1, 0, 0x0f, 0, tafrsqjnefqd }, { 1, 1, 0x07, 0, kdtknwphwltk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, rfuodgfprtbp, NULL };
static const struct gpbqxitaiizd twtmzhovqbcx = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 56, {8, 48, 0, 0}, { 1, 2, 0x7E, 1, plrjbdocqtqa }, { 1, 0, 0x0f, 0, tafrsqjnefqd }, { 1, 1, 0x07, 0, kdtknwphwltk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, rfuodgfprtbp, &wmibezdihnyi };
static const struct gpbqxitaiizd rdbklojlstgw = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, furrpwcvfmwl }, { 1, 1, 0x07, 0, glchtfgsebbd }, { 1, 0, 0x03, 0, zveummuuqpoh }, { 2, 1, 0xff, 0, vmfvhyyvcdpo }, &grfxrbdiwsvt, {.gecmoisvuikh.lnrpcoyamxnd = {{2, 9}, 4, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bgzdumfejgds, NULL };
static const struct gpbqxitaiizd clnhwamowkyw = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 52, {52, 0, 0, 0}, { 0, 5, 0x0f, 0, cmntsrwmylfh }, { 0x0, 5, 0x70, 4, llwlyvriyeuj }, { 0, 4, 0x07, 0, fwzhjkcbkbzj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, jtjaworrdkzn, NULL };
static const struct gpbqxitaiizd aoqibywntfwz = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 285, {5, 64, 64, 152}, { 3, 6, 0xfe, 1, sknaonxhcbby }, { 3, 5, 0x70, 4, oprimmhycskq }, { 3, 8, 0xf0, 4, wrutisakyhxe }, { 0, 0, 0, 0, NULL }, &hdhadpgqjwdv, {.gecmoisvuikh.lnrpcoyamxnd = {{3, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{3, 9}, 9, 0x0f}}, ffcmssmueytf, NULL };
static const struct gpbqxitaiizd mpzcfhusqhgj = { {0, 1, 0, 0 ,0, 0, 0}, 0x36, 216, {64, 152, 0, 0}, { 1, 6, 0xff, 0, tibdbpfmxuaq }, { 1, 5, 0x70, 4, hhtcymniazqt }, { 1, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL}, &hoseydcoikyy, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igxhjdrvywam, NULL };
static const struct gpbqxitaiizd vmytdcjzlxvt = { {0, 1, 0, 0, 0, 0, 0}, 0x31, 317, {5, 160, 152, 0}, { 2, 6, 0xfe, 1, sknaonxhcbby }, { 2, 5, 0x70, 4, oprimmhycskq }, { 2, 8, 0xf0, 4, cxneheyfiqpy }, { 0, 0, 0, 0, NULL }, &ehbtnshbflmy, {.gecmoisvuikh.lnrpcoyamxnd = {{2, 9}, 5, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{1, 3}, 12, 0x80}}, nhhwiyuxkfjo, NULL };
static const struct gpbqxitaiizd gdjqmrsajqgq = { {0, 1, 0, 0, 0, 1, 0}, 0x30, 128, {64, 64, 0, 0}, { 0, 6, 0xff, 0, ypgweitsalat }, { 0, 1, 0x0f, 0, kuduzvpllyzr }, { 0, 1, 0xf0, 4, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 7, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bjxkhzdelqda, &svnlxylljumb };
static const struct gpbqxitaiizd gamslaskhoox = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 424, {24, 400, 0, 0}, { 1, 10, 0x3c, 2, cmntsrwmylfh }, { 1, 22, 0x07, 0, jqhzoursarms }, { 1, 22, 0x70, 4, oxczxmxtlfvg }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 24, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd njqemqxhtihu = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 0x1, 0xff, 0, ypgweitsalat }, { 0, 0, 0x07, 0, ayoirfczdouv }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0x80, 0, 0, 0, NULL }, &bvohqzxijlym, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,8},1,0x16}}, ndnhvunsikoa, NULL };
static const struct gpbqxitaiizd ywaxzsmxakql = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 64, {20, 44, 0, 0}, { 1, 0, 0xf0, 4, cmntsrwmylfh }, { 1, 0, 0x03, 0, rwdoaalpkfsr }, { 1, 0, 0x0c, 2, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, estftcmkqfof, NULL };
static const struct gpbqxitaiizd pjdmyldzugco = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x0f, 0, uwhhynzlqhub }, { 0, 2, 0x0e, 1, suqrsgzbyjrl }, { 0, 1, 0x60, 5, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &alafjlhsckiu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd pawvrziiuoqw = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 192, {32, 160, 0, 0}, { 1, 6, 0x1e, 1, cmntsrwmylfh }, { 1, 4, 0x07, 0, jmmwdmxpdceu }, { 1, 8, 0x07, 0, evgslnjlbbxv }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, lfhmumvqjfmw, NULL };
static const struct gpbqxitaiizd pigpuzhivami = { {1, 0, 0, 0, 0, 0, 0}, 0x35, 80, {80, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 1, 0x0f, 0, promikpkgqdf }, { 0, 1, 0xe0, 5, fxrzumoltkin }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, fvzpivxekuqk, NULL };
static const struct gpbqxitaiizd oblwypmzqqru = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 56, {56, 0, 0, 0}, { 0, 2, 0x1f, 0, kcaqxotfygwa }, { 0, 1, 0x03, 0, edxqfohleqap }, { 0, 1, 0x38, 3, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &eeoztqejihpd };
static const struct gpbqxitaiizd aibeofpgcayo = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 120, {56, 64, 0, 0}, { 1, 1, 0xF0, 4, cmntsrwmylfh }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)lrsrbesgrqom}, rfuodgfprtbp, NULL };
static const struct gpbqxitaiizd xdsnoxvimaja = { {0, 1, 0, 0, 0, 0, 0}, 0x34, 56, {12, 44, 0, 0}, { 1, 3, 0x0f, 0, cmntsrwmylfh }, { 1, 4, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kbrdlavnrake, NULL };
static const struct gpbqxitaiizd ifbsavggkuiu = { {0, 0, 0, 0, 0, 1, 0}, 0x34, 140, {140, 0, 0, 0}, { 0, 16, 0xFF, 0, ypgweitsalat }, { 0, 15, 0xf0, 4, kuduzvpllyzr }, { 0, 15, 0x0f, 0, zdoyojipkifw }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 14, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ciqwjzqbjrek, NULL };
static const struct gpbqxitaiizd bpcscxoinels = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 128, {112, 16, 0, 0}, { 0, 3, 0x3C, 2, cmntsrwmylfh }, { 0x80, 2, 0x0e, 1, jppjhqlrjxqz }, { 0, 2, 0x70, 4, gmuaoolsoaak }, { 0, 3, 0x02, 1, qmxxozupvoyv }, &imgevadfbvyb, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, NULL };
static const struct gpbqxitaiizd vjjajeyubvwc = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 64, {48, 16, 0, 0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0, 1, 0xc0, 6, dbffjkhqcczz }, { 0x80, 1, 0x30, 4, zveummuuqpoh }, { 1, 0, 0x07, 0, fdtplomslzix }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kbcaoyuymqjy, NULL };
static const struct gpbqxitaiizd fjghehxvmpso = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 46, {46, 0, 0, 0}, { 0, 3, 0x0f, 0, cmntsrwmylfh }, { 0, 1, 0x07, 0, vfrrxicjjbuw }, { 0, 2, 0x70, 4, xmpbznnszzgm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x38}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, vqtkjssfeyaz, NULL };
static const struct gpbqxitaiizd zdsvwkxfwwye = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0, 4, 0x1f, 2, huqcmroqemjh }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 5, 0x40}}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd ugfojyvumcdy = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 64, {64, 0, 0, 0}, { 0, 1, 0x1f, 0, tzobemjbbfwa }, { 0, 4, 0x70, 4, sktvbrbbkqlo }, { 0, 4, 0x03, 0, eerwapzvukix }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 3}, 5, 0x40}}, mebltbcdobtk, NULL };
static const struct gpbqxitaiizd oajqqcxnslfa = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 96, {96, 0, 0, 0}, { 0, 1, 0x0f, 0, tsdmfgpfasfa }, { 0, 5, 0xe0, 5, oqmqtbrtarwr }, { 0, 7, 0x60, 5, zveummuuqpoh }, { 0, 1, 0xf0, 4, thwsnzxdiqor }, &alafjlhsckiu, {.gecmoisvuikh.lnrpcoyamxnd={{0, 9}, 3, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0} }, czblcwvndhot, NULL };
static const struct gpbqxitaiizd wpscolqlodvq = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, tsdmfgpfasfa }, { 0, 1, 0x07, 0, nhuuaeatpxut }, { 0, 2, 0x07, 0, evgslnjlbbxv }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, geqprwnpiqkn, NULL };
static const struct gpbqxitaiizd sntjoahwcrzq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {23, 8, 23, 8}, { 1, 0, 0x78, 3, cmntsrwmylfh }, { 0, 0, 0x38, 3, oqmqtbrtarwr }, { 1, 0, 0x07, 0, kuwjmesodnrm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, zojrkykrpxnk, NULL };
static const struct gpbqxitaiizd qlbcetjfrsfk = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 62, {25, 6, 25, 6}, { 1, 0, 0x0f, 0, skkuscfhnkez }, { 0, 0, 0xe0, 5, vucznueqscto }, { 0, 1, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, zojrkykrpxnk, NULL };
static const struct gpbqxitaiizd crjxlurkwefr = { {0, 1, 0, 0, 0, 0, 0}, 0x3C, 85, {76, 9, 0, 0}, { 0, 2, 0xFF, 0, ypgweitsalat }, { 0, 0, 0x70, 4, lnrhfixuybse }, { 0, 1, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 1}, 0, 0x0F}, .gecmoisvuikh.aqpwroyoznxu = {{0,0}, 0, 0}}, gsmtbuovbyaf, NULL };
static const struct gpbqxitaiizd wvyxtrtwrxnm = { {0, 1, 0, 0, 0, 1, 0}, 0x36, 86, {43, 43, 0, 0}, { 0, 2, 0xf0, 4, ontgfftakrct }, { 0x80, 0, 0x0c, 2, iexxstwfurfd }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 4, 0x30, 4, trkkztrvkfxv }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 0, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ugeujihichum, NULL };
static const struct gpbqxitaiizd oaalqllepdsn = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 10, 0x7c, 2, tsdmfgpfasfa }, { 0, 6, 0xe0, 5, tghruybtsqpf}, { 0, 4, 0xe0, 5, ssgjvfhyuect}, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 9, 0x20}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &gqprjzhldwak };
static const struct gpbqxitaiizd sjaotlbjyyjo = { {1, 1, 0, 0, 0, 0, 0}, 0x36, 96, {48, 48, 0, 0}, { 0, 2, 0x1e, 1, furrpwcvfmwl }, { 0, 1, 0x07, 0, oyapdunuwhxp }, { 0, 1, 0x38, 3, txrpvrhoawwv }, { 0, 0, 0, 0, NULL}, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, tepikmqypoha, &lcgbwbeiwtib };
static const struct gpbqxitaiizd hnsoafmrddfg = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 8, 0x1e, 1, ontgfftakrct }, { 0x0, 8, 0xe0, 5, fsrpwjnnruda }, { 0, 6, 0x70, 4, gmcoqyvowqls }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 6, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, ksntmuuzguel, &wkkhzutktiar };
static const struct gpbqxitaiizd mijjeaqtmtkg = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x7e, 1, exlhnycqjhzi }, { 0x0, 6, 0x0f, 0, myniptpptjsc }, { 0, 8, 0x07, 0, kuwjmesodnrm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &nvxftztlbfva };
static const struct gpbqxitaiizd tflnqulhnrgo = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 33, {1, 32, 0, 0}, { 1, 0, 0x1e, 1, uwhhynzlqhub }, { 1, 1, 0xe0, 5, suqrsgzbyjrl }, { 1, 0, 0x60, 5, uwfodcrrykio }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, kxlyncbrsfvl, &oidzjbaffppw };
static const struct gpbqxitaiizd fkrxerppfiov = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 7, 0x1e, 1, vcslgboymbrm }, { 0x80, 6, 0x07, 0, cjwtggkjrket }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 8, 0xc0, 6, hzlfkoyghsgg }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &nbuuzstcaeoz };
static const struct gpbqxitaiizd swiidvcomeol = { {0, 1, 0, 0, 0, 0, 0}, 0x30, 108, {36, 36, 36, 0}, { 0, 2, 0xf0, 4, uwhhynzlqhub }, { 0, 3, 0x0c, 2, bbmoirnyyvpa }, { 0, 3, 0x03, 0, rgospvmfksfb }, { 0, 2, 0x0c, 2, tamwmprilcmd }, &kcojmoonhiie, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 2, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, cudbvananeib, &frweqmdbkymq };
static const struct gpbqxitaiizd wpxlcrjchktc = { {0, 0, 0, 0, 0, 0, 0}, 0x37, 96, {96, 0, 0, 0}, { 0, 9, 0x1e, 1, uwhhynzlqhub }, { 0x0, 9, 0xe0, 5, oqmqtbrtarwr }, { 0, 7, 0x60, 5, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 7, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &axiqbypxjfhm };
static const struct gpbqxitaiizd qchzocrudsxg = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {56, 120, 0, 0}, { 1, 10, 0x7e, 1, exlhnycqjhzi }, { 0x81, 7, 0x70, 4, xmmbocarwnfb }, { 1, 11, 0x70, 4, xmpbznnszzgm }, { 1, 5, 0xF0, 4, bnzmvxodrorx }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 7, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, igxhjdrvywam, &ijghsafyduzk };
static const struct gpbqxitaiizd hyaaxfqvchdq = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 40, {40, 0, 0, 0}, { 0, 1, 0x1e, 1, jiyzgwqhwaux }, { 0, 2, 0x06, 1, dflwnjfakmyn }, { 0, 1, 0xc0, 6, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x01}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, &mvahknhdntlr };
static const struct gpbqxitaiizd nuclqqklnsia = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 32, {32, 0, 0, 0}, { 0, 3, 0x7e, 1, exlhnycqjhzi }, { 0, 1, 0xf0, 4, xgwistjfovfg }, { 0, 1, 0x0e, 1, kuwjmesodnrm }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 2, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, &sspynytwwfik };
static const struct gpbqxitaiizd ojvwdhevbvmm = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 104, {104, 0, 0, 0}, { 0, 9, 0x0f, 0, cmntsrwmylfh }, { 0, 6, 0x7f, 0, lbjnlnoqtjre }, { 0, 7, 0x03, 0, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, czblcwvndhot, &zbvpuzkthise };
static const struct gpbqxitaiizd sslyvqndtjgd = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 48, {48, 0, 0, 0}, { 0, 0, 0x1e, 1, zbyuugoskdnw }, { 0x80, 1, 0x03, 0, svyugtaogvsg }, { 0, 1, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0x60, 5, bbmoirnyyvpa }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, czblcwvndhot, &iloffpvlgzkj };
static const struct gpbqxitaiizd nnxnhxoevaaw = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 72, {72, 0, 0, 0}, { 0, 2, 0x1e, 1, cmntsrwmylfh }, { 0, 1, 0x70, 4, xbhgwzixmpds }, { 0, 7, 0x03, 0, pholksftlwlf }, { 0, 1, 0x0c, 2, nsqgxdctwjwr }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 0}, 0, 0}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, &gcleefidtsko };
static const struct gpbqxitaiizd aanelqcijmje = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 56, {56, 0, 0, 0}, { 0, 1, 0x7e, 1, plrjbdocqtqa }, { 0, 0, 0, 0, NULL }, { 0, 0, 0x07, 0, kgpncohttvpp }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x09}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, czblcwvndhot, &mvahknhdntlr };
static const struct gpbqxitaiizd ffxyyfysxuep = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 88, {88, 0, 0, 0}, { 0, 2, 0x7e, 1, exlhnycqjhzi }, { 0, 1, 0x70, 4, mfggenbbsmvw }, { 0, 1, 0x07, 0, txrpvrhoawwv }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, mebltbcdobtk, &lcgbwbeiwtib };
static const struct gpbqxitaiizd gmhwktvyafmf = { {0, 1, 1, 0, 0, 0, 0}, 0x34, 128, {56, 72, 0, 0}, { 1, 1, 0xf8, 3, rrdygacrtxau }, { 1, 2, 0x07, 0, oqmqtbrtarwr }, { 1, 3, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.lztusevbiwbk = (bc7215DataVarPkt_t*)nwjarwwisfjy}, rfuodgfprtbp, &sfkelpzmrzlt };
static const struct gpbqxitaiizd pbfhmbekjeol = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 68, {68, 0, 0, 0}, { 0, 1, 0x0e, 1, uwhhynzlqhub }, { 0, 0, 0x07, 0, oqmqtbrtarwr }, { 0, 0, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 0, 0x08}, .gecmoisvuikh.aqpwroyoznxu = {{0,0},0,0}}, ndnhvunsikoa, &vwfarzudiigm };
static const struct gpbqxitaiizd vlkrufrymfsr = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 112, {112, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 7, 0xe0, 5, tghruybtsqpf }, { 0, 5, 0xe0, 5, ssgjvfhyuect }, { 0, 12, 0x07, 0, haylvzeejxtf }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 4, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &fkpxcrqrnjct };
static const struct gpbqxitaiizd apnbirljndbu = { {1, 0, 0, 0, 0, 0, 0}, 0x37, 72, {72, 0, 0, 0}, { 0, 1, 0xf0, 4, cmntsrwmylfh }, { 0x0, 6, 0x07, 0, oqmqtbrtarwr }, { 0, 6, 0x30, 4, nvjodrzzlddk }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 1, 0x02}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &kqdefetwjhjv };
static const struct gpbqxitaiizd kagsoeptommd = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 168, {16, 96, 56, 0}, { 1, 1, 0xf0, 4, cmntsrwmylfh }, { 1, 1, 0x07, 0, glchtfgsebbd }, { 1, 0, 0x03, 0, zveummuuqpoh }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{2, 9}, 4, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bgzdumfejgds, &bolofrnxfnbs };
static const struct gpbqxitaiizd meukksltgbmp = { {1, 0, 0, 0, 0, 0, 0}, 0x34, 28, {28, 0, 0, 0}, { 0, 2, 0xf0, 4, drkbwjcqomkf }, { 0, 1, 0x07, 0, nhuuaeatpxut }, { 0, 2, 0x07, 0, evgslnjlbbxv }, { 0, 1, 0x08, 3, xcjqyivqssjo }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0xc0}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, bjxkhzdelqda, &svnlxylljumb };
static const struct gpbqxitaiizd tksmkqyjqieo = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 176, {40, 136, 0, 0}, { 1, 5, 0x1E, 1, cmntsrwmylfh }, { 1, 6, 0x07, 0, edxqfohleqap }, { 1, 7, 0x0E, 1, ivclzcupstut }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x40}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, &tzdolwhmeely };
static const struct gpbqxitaiizd vcgfftturmbb = { {0, 1, 0, 0, 0, 0, 0}, 0x33, 168, {12, 44, 68, 44}, { 3, 3, 0x0f, 0, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{3, 9}, 5, 0x03}}, sifulwqeulvu, &wjzlthcmibqi };
static const struct gpbqxitaiizd fgqezcynutlq = { {0, 1, 0, 0, 0, 0, 0}, 0x36, 170, {12, 44, 70, 44}, { 3, 3, 0x1e, 1, cmntsrwmylfh }, { 3, 4, 0x07, 0, oqmqtbrtarwr }, { 3, 3, 0xe0, 5, kqnqeirkhepj }, { 0, 0, 0, 0, NULL }, &tnzlmvpodknl, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 5, 0x03}, .gecmoisvuikh.aqpwroyoznxu = {{3, 9}, 5, 0x03}}, sifulwqeulvu, &fkcfehqixyem };
static const struct gpbqxitaiizd khvvcssforjm = { {0, 1, 0, 0, 0, 0, 0}, 0x37, 48, {40, 8, 0, 0}, { 0x80, 3, 0x0e, 1, idrqzusdprtf }, { 0, 2, 0x07, 0, ybmndoxkcgvq }, { 0, 2, 0x60, 5, hbkwawzvifnd }, { 1, 0, 0x0f, 0, asiupcazjtid }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 3}, 1, 0x10}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, nxxkpocakeer, &usoclgqcnwde };
static const struct gpbqxitaiizd fyufkvpqlcfb = { {1, 1, 0, 0, 0, 0, 0}, 0x34, 72, {8, 64, 0, 0}, { 1, 3, 0x7e, 1, exlhnycqjhzi }, { 1, 1, 0x07, 0, oqmqtbrtarwr }, { 1, 1, 0x70, 4, kgpncohttvpp }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{1, 9}, 0, 0x80}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, igqtdsgitzoh, &hjctogzkgskg };
static const struct gpbqxitaiizd kzbcwpalqjva = { {0, 0, 0, 0, 0, 0, 0}, 0x34, 120, {120, 0, 0, 0}, { 0, 13, 0x1e, 1, vcslgboymbrm }, { 0, 6, 0x0f, 0, jnioisscmtak }, { 0, 8, 0x07, 0, kfiokuecrvod }, { 0, 0, 0, 0, NULL }, &nbdnkukqfqmu, {.gecmoisvuikh.lnrpcoyamxnd = {{0, 9}, 5, 0x04}, .gecmoisvuikh.aqpwroyoznxu = {{0, 0}, 0, 0}}, czblcwvndhot, &iagydowakuyr };
static const struct gpbqxitaiizd* cnwdpipbbuwu[] = { &hphrihomgvhs, &ewddpgbncxwr, &uqdnhwcyeiyn, &kqussebgshnu, &kmnwvjvjdwvq, &gghmehwbbirj, &conthumzlpco, &niyxkpniwohx, &rlzksymkktib, &owpyysmsawlz, &turkmfyaperg, &jdicjwykokzq, &vwyuehyhjkcu, &fnhhryoehnkz, &nrkxomwlhjue, &yzkicewtgtzx, &ysfajdvqhgew, &qkbnuoiosxhe, &scmhgpfuqwlk, &qytehikcoevs, &shutefsgttuf, &hkowiktqhfzs, &mmuaruzhkbtc, &fhjasrdyfcqc, &ehcntcgyyfbs, &aeloimaxwamf, &byqanbrxskph, &bystkddanudk, &ahnbwbztlaqb, &oqhkfplzqygm, &xzdtjuaiwpmf, &nwskzajjztey, &ztoopuwhxaqb, &tkcwqlinwpwt, &jizgqpswgmzb, &kpbcfrfbfkdq, &fzzwckumztwv, &amzykpfpkgmc, &fmcgdzmybgln, &swapplqzmyny, &epepleuvkqmw, &sqfmtqvmyrer, &bhbpgboyvqgk, &zcgrmptqmmjc, &rxhcbhfnaspr, &whfuafrlctxn, &qilghsfijxad, &lmvlflntnzep, &pknydaggdioj, &auftxbzqnwfz, &whncwjlxhzko, &kquuumnhfdbm, &ynocknvbwvtr, &gxxgvlluztbh, &lohwxfaygqon, &cugrippztfgq, &oflcnphcchko, &nanbjalaeuvy, &gvztlymvwvps, &usczmayaroaj, &xhlnpjkuuphv, &rloqmdbazvhi, &jdcputcrozvk, &cuxbkomreukb, &bcjwagxugurw, &fcifwqeiweis, &lzecgkhtywuj, &sgkrgxkklxlv, &flekhblsejmg, &slbylqnqgvzc, &ocuzxmnpigwa, &eoldtcyeugkk, &qdghbpwfnjkz, &yhzoahnqpxxh, &gwjlpjolsvmk, &xycuwfxxcifd, &gdydrjmbjxrr, &aloiqjwdwtgo, &jckvfqucizfw, &yjolkncjhqgu, &qxtksxilpous, &ahyjutgpitfo, &iyxycrjlgsai, &akwhlnficqin, &weunfbwsltgs, &rtlpqmnkilcd, &oimjaqywsigs, &bzvdugxbvdra, &brreygbdnbop, &crvxozwprecv, &kxkdrkbjaolu, &wycbqpfredhu, &quaugbthkggk, &frvdprgwgrle, &ilbhxnaabzyg, &erpekfehcrhs, &hjfbwjbtaeci, &jxydsfilacuj, &cvvxzetagjzo, &vhkdfhlnkvog, &tyctbkebajmz, &kayrjhfjefdr, &pverbdfjbynw, &yjbaxhjiasht, &mmxwrbegvhif, &bchfpzjwyyzq, &uubylrhxqdjv, &hxqywwrxcpad, &heohynfatxwl, &cqbxzirerlcz, &wtcwfdjkglbn, &npvlvjeskbjp, &xctmfwosqadw, &gpstnahujjjt, &mahotgxpafpn, &ihftwtmjokcy, &ugsyfeiousgk, &ogophkvjgbgq, &rqblscbetsku, &uqfrdcijahbn, &cwnyaweelauk, &veppqzgkcwxa, &owyrjknhibbq, &ulclftuloupl, &tjbckkvfmuzc, &jqfxvdaldqti, &kixkachqhgxm, &qlkwsplmlxxu, &iinauwztyhtq, &giltllkqimaq, &ftxxqmbjjsdi, &rhkkgxcgdszi, &axtlhgesujwz, &opwkbtmblfkk, &mxpgyiwrgzls, &zzzalzebsece, &fweqefxyrayk, &febqygkpducf, &clkpqifqojxx, &czzugxbmrwat, &xhfhwwdgvvov, &fsprzrcpusot, &ltqjpfleahgl, &berhuoftzatq, &jnnjlqttaawt, &sdcxqlaqrbze, &ljchafgodnoy, &mugvzitdydws, &oajqqcxnslfa, &edjdozslltkq, &trbwaneynklu, &svknsbjhsqkr, &uolpkicrjvas, &pwmpntwzcyrs, &dgybpdvkzaps, &kzbcwpalqjva, &tvkapeulemxo, &zdhnvgegjmok, &gwkpmwlueund, &kawrmqcxefrq, &wonnolwwyjoi, &pqvlccdogfop, &krppsvwkmxuy, &tvewknkkdxpn, &kgejskcuvuor, &gntgkjyewxko, &fsaaejorraxh, &rfprlrerbift, &lriwksytvocn, &bwupnkcrkiqs, &frjonxghfyhr, &gzyabegxxfux, &iocpxioxgwiv, &bykcxrhccvkw, &kbxtedwgjrxl, &mupcowuytnbo, &zlkkibrhxpkb, &gjsqihzgltcg, &gbkrozbbniqv, &yaacbidcxqab, &fhumgzymonvx, &rvfxcklyarhc, &ukhmrhdyenqc, &vgkzjjlggisn, &bgwxvfffawil, &xwxoyewoqbkk, &wvivwpzlmjfj, &kkemsewtocsm, &mlwazxtpyxam, &pzndabqqnhip, &qfglwecimhwj, &vyvkvtvzvkot, &mespjqfkaxfx, &mupchketvfjs, &yekdcttxuoou, &utortrgmqnpi, &lrvkaxmbbuxk, &gedgfkrqvtpt, &kekcwozbekyv, &nfofbpdpsajo, &esbudowscame, &hirxzplccxcl, &kqpaqebllmpv, &bzsxihoogbiq, &msqeuttrvezv, &gvpslonsorlw, &znclkdnjtoqp, &qawblprzgjnv, &mdmlqsyyarjs, &isedljrkknwe, &lcvluxgkpxuf, &unobicdrwlcp, &tsjnrjaxikkw, &apdcsqgbxjhb, &zufkkpgwjjqz, &hizekitbfwzc, &upmtgbvymhaf, &tekorjstpjbp, &dagrouszppkl, &ofwkiawyjfsq, &onhvchrojvab, &yhxrtikljxhy, &ujkgzmselnra, &zydrksiyikcq, &dpndrhztsnad, &npzwquhpbdgo, &fvjztvgjvdvh, &ovzoqhjyriyc, &lkxubfnzxtll, &fzqptiluekii, &bhetectmiqcj, &txhetlrkjejm, &npffcbnscufi, &rdbklojlstgw, &clnhwamowkyw, &aoqibywntfwz, &mpzcfhusqhgj, &vmytdcjzlxvt, &gdjqmrsajqgq, &gamslaskhoox, &njqemqxhtihu, &ywaxzsmxakql, &pjdmyldzugco, &pawvrziiuoqw, &pigpuzhivami, &oblwypmzqqru, &aibeofpgcayo, &xdsnoxvimaja, &ifbsavggkuiu, &pxyxjilgbnvi, &ablknklbhmyf, &skfmovwktrrq, &yqccrlbjtier, &bpcscxoinels, &vjjajeyubvwc, &gvwsmjdfamfj, &fjghehxvmpso, &zdsvwkxfwwye, &ugfojyvumcdy, &wpscolqlodvq, &sntjoahwcrzq, &qlbcetjfrsfk, &crjxlurkwefr, &wvyxtrtwrxnm, &oaalqllepdsn, &sjaotlbjyyjo, &hnsoafmrddfg, &mijjeaqtmtkg, &tflnqulhnrgo, &fkrxerppfiov, &swiidvcomeol, &wpxlcrjchktc, &qchzocrudsxg, &hyaaxfqvchdq, &nuclqqklnsia, &ojvwdhevbvmm, &sslyvqndtjgd, &nnxnhxoevaaw, &twtmzhovqbcx, &aanelqcijmje, &ffxyyfysxuep, &gmhwktvyafmf, &pbfhmbekjeol, &vlkrufrymfsr, &apnbirljndbu, &nopmvthazrfx, &kagsoeptommd, &meukksltgbmp, &tksmkqyjqieo, &pbutyhykyfli, &vcgfftturmbb, &xqtvuyolcfqv, &fgqezcynutlq, &bapantvdsdcw, &agddqiceqteq, &khvvcssforjm, &fyufkvpqlcfb, &cbdugghduwib, &pkjoeazqzgyn, &rfkrcbneoyrv, &dlchrrirbmpe, &gqjabkprnssk, &gxkkbcqmavdb };
static const uint16_t elwxztlbomnj=sizeof(cnwdpipbbuwu)/sizeof(struct gpbqxitaiizd*);
static uint8_t slchrdesbcgd(const zecqpcygsbxm* npuwofjjnfva, uint8_t ndrkzeftfrps, bool jljdeclqfqml) { uint8_t iwycwegyajgo;
uint8_t rrduylrjfejn;
uint8_t cmzquequdqnx = 0;
if (npuwofjjnfva->npuwofjjnfva != NULL) { iwycwegyajgo = (qaecoxiakqno[npuwofjjnfva->lwvakrvplqdt&0x03][npuwofjjnfva->ecxwwscrklsl&0x3f]&npuwofjjnfva->cglziorkljus)>>npuwofjjnfva->agxxkyjkfjvo;
rrduylrjfejn = npuwofjjnfva->npuwofjjnfva[ndrkzeftfrps]&(npuwofjjnfva->cglziorkljus>>npuwofjjnfva->agxxkyjkfjvo);
if (npuwofjjnfva->lwvakrvplqdt&0x20) { const struct ojyxxaaevkqk* hcaosujmqxrq = (const struct ojyxxaaevkqk*)(npuwofjjnfva->npuwofjjnfva);
rrduylrjfejn = ((const uint8_t*)hcaosujmqxrq->yzanflvvuasy)[ndrkzeftfrps];
} if (!(npuwofjjnfva->lwvakrvplqdt & 0x40)) { if (npuwofjjnfva->ecxwwscrklsl & 0x80) { cmzquequdqnx = ((rrduylrjfejn&0xf0)-(iwycwegyajgo&0xf0)) | ((rrduylrjfejn-iwycwegyajgo)&0x0f);
} else if (npuwofjjnfva->ecxwwscrklsl & 0x40) { cmzquequdqnx = ((rrduylrjfejn>>4)+(rrduylrjfejn&0x0f)) - ((iwycwegyajgo>>4)+(iwycwegyajgo&0x0f));
} else { cmzquequdqnx = rrduylrjfejn - iwycwegyajgo;
} } if (jljdeclqfqml) { qaecoxiakqno[npuwofjjnfva->lwvakrvplqdt&0x03][npuwofjjnfva->ecxwwscrklsl&0x3f] = (qaecoxiakqno[npuwofjjnfva->lwvakrvplqdt&0x03][npuwofjjnfva->ecxwwscrklsl&0x3f]&(~npuwofjjnfva->cglziorkljus)) | ((rrduylrjfejn<<npuwofjjnfva->agxxkyjkfjvo)&npuwofjjnfva->cglziorkljus);
} } return cmzquequdqnx;
} static bool dapkfliuefws(const struct gpbqxitaiizd* hxzmznxdkbkc, bool bnvuxeuihuzu) { uint8_t ntylrpbzdrae = 0;
algorithm_t jqbnlvovznke;
dutkzlcvtldb = NULL;
while (hxzmznxdkbkc->qfzhqhdtlzxl[ntylrpbzdrae].kggtrdhlamff != NULL) { jqbnlvovznke = hxzmznxdkbkc->qfzhqhdtlzxl[ntylrpbzdrae].kggtrdhlamff;
if (!jqbnlvovznke(hxzmznxdkbkc, hxzmznxdkbkc->qfzhqhdtlzxl[ntylrpbzdrae].dfmcnuofogss, bnvuxeuihuzu)) { return false;
} ntylrpbzdrae++;
} return true;
} static bool rrgvexenfoby(const struct muedplmamryr* gecmoisvuikh, bool bnvuxeuihuzu) { uint8_t qbjrufimapgn;
qbjrufimapgn = qaecoxiakqno[gecmoisvuikh->axlnvuvqassa.srnwqkyvmfzi][gecmoisvuikh->ecxwwscrklsl];
if (bnvuxeuihuzu) { qaecoxiakqno[gecmoisvuikh->axlnvuvqassa.srnwqkyvmfzi][gecmoisvuikh->ecxwwscrklsl] = ytomqlzpvxsh[gecmoisvuikh->axlnvuvqassa.uzeqpjupwhmw](qbjrufimapgn, gecmoisvuikh->bits);
return true;
} else { return qaecoxiakqno[gecmoisvuikh->axlnvuvqassa.srnwqkyvmfzi][gecmoisvuikh->ecxwwscrklsl] == ytomqlzpvxsh[gecmoisvuikh->axlnvuvqassa.uzeqpjupwhmw](qbjrufimapgn, gecmoisvuikh->bits);
} } static void mswzehfcxide(bc7215DataVarPkt_t* vpxwfpopdveh, int8_t xdbkzgbvvxyi, uint8_t axibwwjngsht) { uint8_t ntylrpbzdrae;
int8_t wohhjvtfkund;
bool shiftOutBit=0;
for (ntylrpbzdrae=0; ntylrpbzdrae<axibwwjngsht; ntylrpbzdrae++)
{ for (wohhjvtfkund=(vpxwfpopdveh->bitLen+7)/8-1; wohhjvtfkund>=xdbkzgbvvxyi; wohhjvtfkund--)
{ if (vpxwfpopdveh->data[wohhjvtfkund] & 0x80) { vpxwfpopdveh->data[wohhjvtfkund] <<= 1;
if (shiftOutBit == 1) { vpxwfpopdveh->data[wohhjvtfkund] |= 0x01;
} shiftOutBit = 1;
} else { vpxwfpopdveh->data[wohhjvtfkund] <<= 1;
if (shiftOutBit == 1) { vpxwfpopdveh->data[wohhjvtfkund] |= 0x01;
} shiftOutBit = 0;
} } } } static void ozczccvdolvj(bc7215DataVarPkt_t* vpxwfpopdveh, int8_t xdbkzgbvvxyi, uint8_t axibwwjngsht) { uint8_t ntylrpbzdrae;
int8_t wohhjvtfkund;
bool shiftOutBit=0;
for (ntylrpbzdrae=0; ntylrpbzdrae<axibwwjngsht; ntylrpbzdrae++)
{ for (wohhjvtfkund=(vpxwfpopdveh->bitLen+7)/8-1; wohhjvtfkund>=xdbkzgbvvxyi; wohhjvtfkund--)
{ if (vpxwfpopdveh->data[wohhjvtfkund] & 0x01) { vpxwfpopdveh->data[wohhjvtfkund] >>= 1;
if (shiftOutBit == 1) { vpxwfpopdveh->data[wohhjvtfkund] |= 0x80;
} shiftOutBit = 1;
} else { vpxwfpopdveh->data[wohhjvtfkund] >>= 1;
if (shiftOutBit == 1) { vpxwfpopdveh->data[wohhjvtfkund] |= 0x80;
} shiftOutBit = 0;
} } } } static void tkkyhdxekifj(uint8_t axlnvuvqassa[][BC7215_MAX_RX_DATA_SIZE], bc7215DataVarPkt_t* vpxwfpopdveh, const struct gpbqxitaiizd* hxzmznxdkbkc) { uint16_t wmvilyubkefv = 0;
uint8_t httasluzlyzk = 0;
uint8_t ntylrpbzdrae;
uint8_t wxrppogmmpte = 0;
uint8_t edxwkqetbbwb;
uint8_t qyxxhiqlzuwz;
uint16_t ahwwhfluyewp;
ahwwhfluyewp = hxzmznxdkbkc->aevxhrsgdbyw[0]+hxzmznxdkbkc->aevxhrsgdbyw[1]+hxzmznxdkbkc->aevxhrsgdbyw[2]+hxzmznxdkbkc->aevxhrsgdbyw[3];
while (wmvilyubkefv < ahwwhfluyewp) { edxwkqetbbwb = wxrppogmmpte+(hxzmznxdkbkc->aevxhrsgdbyw[httasluzlyzk]+7)/8;
for (ntylrpbzdrae=wxrppogmmpte; ntylrpbzdrae<edxwkqetbbwb; ntylrpbzdrae++)
{ axlnvuvqassa[httasluzlyzk][ntylrpbzdrae-wxrppogmmpte] = vpxwfpopdveh->data[ntylrpbzdrae];
} qyxxhiqlzuwz = hxzmznxdkbkc->aevxhrsgdbyw[httasluzlyzk]%8;
if (qyxxhiqlzuwz != 0) { if ((hxzmznxdkbkc->signature&0x30) == 0x30) { axlnvuvqassa[httasluzlyzk][edxwkqetbbwb-wxrppogmmpte-1] &= zbhuqvjsrngn[qyxxhiqlzuwz];
ozczccvdolvj(vpxwfpopdveh, edxwkqetbbwb-1, qyxxhiqlzuwz);
} else { axlnvuvqassa[httasluzlyzk][edxwkqetbbwb-wxrppogmmpte-1] &= bsnougcexahd[qyxxhiqlzuwz];
mswzehfcxide(vpxwfpopdveh, edxwkqetbbwb-1, qyxxhiqlzuwz);
} wxrppogmmpte = edxwkqetbbwb-1;
} else { wxrppogmmpte = edxwkqetbbwb;
} wmvilyubkefv += hxzmznxdkbkc->aevxhrsgdbyw[httasluzlyzk];
httasluzlyzk++;
} } static uint8_t fsdssprrrxul(uint8_t byte) { return (iwrivqhbkfvb[byte & 0x0F] << 4) | iwrivqhbkfvb[byte >> 4];
} static uint8_t ngjjwymkotrg(uint8_t byte) { return (gdqhvoumubms[byte >> 4]<<4) | gdqhvoumubms[byte & 0x0f];
} static void oyvkixyldkse(const struct gpbqxitaiizd* hxzmznxdkbkc) { uint8_t ntylrpbzdrae, wohhjvtfkund;
for (ntylrpbzdrae=0; ntylrpbzdrae<4; ntylrpbzdrae++)
{ for (wohhjvtfkund=0; wohhjvtfkund<(hxzmznxdkbkc->aevxhrsgdbyw[ntylrpbzdrae]+7)/8; wohhjvtfkund++)
{ qaecoxiakqno[ntylrpbzdrae][wohhjvtfkund] = fsdssprrrxul(qaecoxiakqno[ntylrpbzdrae][wohhjvtfkund]);
} } } static void yxbwbukfxifv(const struct gpbqxitaiizd* hxzmznxdkbkc) { uint8_t ntylrpbzdrae, wohhjvtfkund;
for (ntylrpbzdrae=0; ntylrpbzdrae<4; ntylrpbzdrae++)
{ for (wohhjvtfkund=0; wohhjvtfkund<(hxzmznxdkbkc->aevxhrsgdbyw[ntylrpbzdrae]+7)/8; wohhjvtfkund++)
{ qaecoxiakqno[ntylrpbzdrae][wohhjvtfkund] = ngjjwymkotrg(qaecoxiakqno[ntylrpbzdrae][wohhjvtfkund]);
} } } static bool vuawcztbcsbf(const struct gpbqxitaiizd* hxzmznxdkbkc) { uint8_t eadkjmamtpav;
if (fahrenheitInit) { if (jxdluxfodxlj->dbooiubuftmj != NULL) { eadkjmamtpav = jxdluxfodxlj->dbooiubuftmj->nrzmlxiqnvjp[78-60];
} else { eadkjmamtpav = xiomrpyxzinu.nrzmlxiqnvjp[78-60];
} } else { eadkjmamtpav = erzjcdfgghiz-16;
} if (slchrdesbcgd(&hxzmznxdkbkc->mmzlyxxngkvo, eadkjmamtpav, jxusjozdkpwz) != 0) { return false;
} if (slchrdesbcgd(&hxzmznxdkbkc->kgcvzngryhap, MODE_COOL, jxusjozdkpwz) != 0) { return false;
} return dapkfliuefws(hxzmznxdkbkc, jxusjozdkpwz);
} static int8_t moaiqlamhzrj(const zecqpcygsbxm* npuwofjjnfva, uint8_t jekqbozmgthd) { zecqpcygsbxm bpohkywdwfhe = *npuwofjjnfva;
int8_t ntylrpbzdrae;
bpohkywdwfhe.lwvakrvplqdt &= 0x3F;
ntylrpbzdrae = jekqbozmgthd/2;
while (ntylrpbzdrae >= 0) { if (slchrdesbcgd(&bpohkywdwfhe, ntylrpbzdrae, jxusjozdkpwz) == 0) { return ntylrpbzdrae;
} ntylrpbzdrae--;
} for (ntylrpbzdrae=jekqbozmgthd/2+1; ntylrpbzdrae<jekqbozmgthd; ntylrpbzdrae++)
{ if (slchrdesbcgd(&bpohkywdwfhe, ntylrpbzdrae, jxusjozdkpwz) == 0) { return ntylrpbzdrae;
} } return -1;
} static int8_t xpegizsqfutt(const struct lmbejlluhdlz* benrzfbxgfjh, int8_t nicibroattym) { int8_t ntylrpbzdrae, yvofwnzsaryf;
int8_t qsxxgkmcmmgp = -1;
yvofwnzsaryf = 14;
if ((benrzfbxgfjh->nrzmlxiqnvjp[yvofwnzsaryf] == benrzfbxgfjh->nrzmlxiqnvjp[yvofwnzsaryf-1]) && (benrzfbxgfjh->nrzmlxiqnvjp[yvofwnzsaryf] != benrzfbxgfjh->nrzmlxiqnvjp[yvofwnzsaryf+1])) { yvofwnzsaryf = yvofwnzsaryf - 1;
} if (benrzfbxgfjh->nrzmlxiqnvjp[yvofwnzsaryf] <= nicibroattym) { for (ntylrpbzdrae=yvofwnzsaryf; ntylrpbzdrae<29; ntylrpbzdrae++)
{ if (benrzfbxgfjh->nrzmlxiqnvjp[ntylrpbzdrae] == nicibroattym) { qsxxgkmcmmgp = ntylrpbzdrae;
if ((benrzfbxgfjh->kmdfjjawpchr.npuwofjjnfva != NULL ) && (slchrdesbcgd(&benrzfbxgfjh->kmdfjjawpchr, ntylrpbzdrae, jxusjozdkpwz) != 0)) { if ((ntylrpbzdrae<28) && (benrzfbxgfjh->nrzmlxiqnvjp[ntylrpbzdrae+1] == nicibroattym) && (slchrdesbcgd(&benrzfbxgfjh->kmdfjjawpchr, ntylrpbzdrae+1, jxusjozdkpwz) == 0)) { qsxxgkmcmmgp = ntylrpbzdrae+1;
} } return qsxxgkmcmmgp;
} } } else { for (ntylrpbzdrae=yvofwnzsaryf-1; ntylrpbzdrae>=0; ntylrpbzdrae--)
{ if (benrzfbxgfjh->nrzmlxiqnvjp[ntylrpbzdrae] == nicibroattym) { qsxxgkmcmmgp = ntylrpbzdrae;
if ((benrzfbxgfjh->kmdfjjawpchr.npuwofjjnfva != NULL ) && (slchrdesbcgd(&benrzfbxgfjh->kmdfjjawpchr, ntylrpbzdrae, jxusjozdkpwz) != 0)) { if ((ntylrpbzdrae>0) && (benrzfbxgfjh->nrzmlxiqnvjp[ntylrpbzdrae-1] == nicibroattym) && (slchrdesbcgd(&benrzfbxgfjh->kmdfjjawpchr, ntylrpbzdrae-1, jxusjozdkpwz) == 0)) { qsxxgkmcmmgp = ntylrpbzdrae-1;
} } return qsxxgkmcmmgp;
} } } return qsxxgkmcmmgp;
} static int8_t kpqlkeowmbcu(const struct gpbqxitaiizd* hxzmznxdkbkc) { int8_t rziichzxxsgx;
rziichzxxsgx = 1;
if (!hxzmznxdkbkc->spec.wibvdpdgotxx) { if ((hxzmznxdkbkc->qyillnqmaztz.npuwofjjnfva != NULL) && (hxzmznxdkbkc->qyillnqmaztz.npuwofjjnfva[0] != hxzmznxdkbkc->qyillnqmaztz.npuwofjjnfva[4]) && !((hxzmznxdkbkc->mmzlyxxngkvo.lwvakrvplqdt&0x80) || (hxzmznxdkbkc->kgcvzngryhap.lwvakrvplqdt&0x80) || (hxzmznxdkbkc->symhfchmtzss.lwvakrvplqdt&0x80))) { if (slchrdesbcgd(&hxzmznxdkbkc->qyillnqmaztz, 4, jxusjozdkpwz) == 0) { if (hxzmznxdkbkc->qyillnqmaztz.npuwofjjnfva[4] == hxzmznxdkbkc->qyillnqmaztz.npuwofjjnfva[5]) { rziichzxxsgx = 2;
} else { rziichzxxsgx = 0;
return rziichzxxsgx;
} } } if ( !( (jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.lnrpcoyamxnd.axlnvuvqassa.uzeqpjupwhmw == 0) && (jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.lnrpcoyamxnd.bits == 0) && (jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.aqpwroyoznxu.axlnvuvqassa.uzeqpjupwhmw == 0) && (jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.aqpwroyoznxu.bits == 0) ) ) { if ( rrgvexenfoby(&jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.lnrpcoyamxnd, jxusjozdkpwz) && rrgvexenfoby(&jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.aqpwroyoznxu, jxusjozdkpwz) ) { rziichzxxsgx = 0;
} else if (rziichzxxsgx == 2) { rziichzxxsgx = 1;
} if (hxzmznxdkbkc->spec.jooqmrimufrf) { if (rziichzxxsgx == 1) { rziichzxxsgx = -1;
} else { rziichzxxsgx = 2;
} } } } else { rziichzxxsgx = -1;
} return rziichzxxsgx;
} static uint8_t igfdwiopuuhb(uint8_t vpxwfpopdveh, uint8_t bits, uint8_t* alghpasdzcyv) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = vpxwfpopdveh&zbhuqvjsrngn[bits];
vpxwfpopdveh >>= bits;
vpxwfpopdveh |= (*alghpasdzcyv<<(8-bits));
*alghpasdzcyv = byte;
} return vpxwfpopdveh;
} static uint8_t bqkrfrrbcuum(uint8_t vpxwfpopdveh, uint8_t bits, uint8_t* alghpasdzcyv) { uint8_t byte;
if ((bits != 8) && (bits != 0)) { byte = vpxwfpopdveh&bsnougcexahd[bits];
vpxwfpopdveh <<= bits;
vpxwfpopdveh |= (*alghpasdzcyv>>(8-bits));
*alghpasdzcyv = byte;
} return vpxwfpopdveh;
} static void tmvqpybvzasi(const struct gpbqxitaiizd* hxzmznxdkbkc) { uint8_t lwvakrvplqdt;
uint16_t wohhjvtfkund;
uint8_t shzjlrmssuzb = 0;
uint16_t vvqkgsexeirj = 0;
uint8_t wprnbnxbotjl = 0;
uint8_t wojkuuismadf = 0;
uint8_t axibwwjngsht = 0;
uint8_t yiptehbsczhk;
ywvlglmedvkw.bitLen = hxzmznxdkbkc->bitLen;
for (lwvakrvplqdt = 0; lwvakrvplqdt < 4; lwvakrvplqdt++) {
if (hxzmznxdkbkc->aevxhrsgdbyw[lwvakrvplqdt] != 0) { for (wohhjvtfkund = 0; wohhjvtfkund < (hxzmznxdkbkc->aevxhrsgdbyw[lwvakrvplqdt]-axibwwjngsht+7)/8; wohhjvtfkund++) {
wprnbnxbotjl = tlcqethmndyr[lwvakrvplqdt][wohhjvtfkund+1];
if ((hxzmznxdkbkc->signature&0x30) == 0x30) { ywvlglmedvkw.data[shzjlrmssuzb] = igfdwiopuuhb(tlcqethmndyr[lwvakrvplqdt][wohhjvtfkund], axibwwjngsht, &wprnbnxbotjl);
} else { ywvlglmedvkw.data[shzjlrmssuzb] = bqkrfrrbcuum(tlcqethmndyr[lwvakrvplqdt][wohhjvtfkund], axibwwjngsht, &wprnbnxbotjl);
} shzjlrmssuzb++;
} vvqkgsexeirj += hxzmznxdkbkc->aevxhrsgdbyw[lwvakrvplqdt];
wojkuuismadf = vvqkgsexeirj%8;
axibwwjngsht = (8-wojkuuismadf)&0x07;
if ((axibwwjngsht != 0) && (lwvakrvplqdt != 3) && (hxzmznxdkbkc->aevxhrsgdbyw[lwvakrvplqdt+1] != 0)){ if ((hxzmznxdkbkc->signature&0x30) == 0x30) { ywvlglmedvkw.data[shzjlrmssuzb-1] = (ywvlglmedvkw.data[shzjlrmssuzb-1]&zbhuqvjsrngn[wojkuuismadf]) | (tlcqethmndyr[lwvakrvplqdt+1][0] << wojkuuismadf);
} else { ywvlglmedvkw.data[shzjlrmssuzb-1] = (ywvlglmedvkw.data[shzjlrmssuzb-1]&bsnougcexahd[wojkuuismadf]) | (tlcqethmndyr[lwvakrvplqdt+1][0] >> wojkuuismadf);
} } } } if (hxzmznxdkbkc->spec.tvmjtomrdnhm && hxzmznxdkbkc->spec.hwzszqauakcw) { memcpy(bymymfzfytqi.data, ywvlglmedvkw.data, (ywvlglmedvkw.bitLen+7)/8);
memcpy(ywvlglmedvkw.data, prldlpdyrzae.data, (ywvlglmedvkw.bitLen+7)/8);
vvqkgsexeirj = 0;
for (wohhjvtfkund=0; wohhjvtfkund<ywvlglmedvkw.bitLen/2; wohhjvtfkund++)
{ shzjlrmssuzb = wohhjvtfkund/4;
yiptehbsczhk = ywvlglmedvkw.data[shzjlrmssuzb] & picxegsrhkul[wohhjvtfkund%4];
if ((yiptehbsczhk & 0xaa) == 0) { if (bymymfzfytqi.data[vvqkgsexeirj/8] & jzcdxmdrohri[vvqkgsexeirj%8]) { ywvlglmedvkw.data[shzjlrmssuzb] = (ywvlglmedvkw.data[shzjlrmssuzb]&(~picxegsrhkul[wohhjvtfkund%4])) | (0x55 & picxegsrhkul[wohhjvtfkund%4]);
} else { ywvlglmedvkw.data[shzjlrmssuzb] = ywvlglmedvkw.data[shzjlrmssuzb] & (~picxegsrhkul[wohhjvtfkund%4]);
} vvqkgsexeirj++;
} } } } static void xppwyewwolze(const struct gpbqxitaiizd* hxzmznxdkbkc, uint8_t uiwmbgnbvgpr, const bc7215DataVarPkt_t* vpxwfpopdveh) { uint8_t kddzikqenapu;
uint8_t wohhjvtfkund, uzvkrgscbcne;
uint16_t vvqkgsexeirj;
uint8_t yiptehbsczhk;
vvqkgsexeirj = 0;
bymymfzfytqi.bitLen = vpxwfpopdveh->bitLen;
kddzikqenapu = (vpxwfpopdveh->bitLen+7)/8;
for (wohhjvtfkund=0; wohhjvtfkund<kddzikqenapu; wohhjvtfkund++) {
if (hxzmznxdkbkc->spec.tvmjtomrdnhm && hxzmznxdkbkc->spec.hwzszqauakcw) { for (uzvkrgscbcne= 0; uzvkrgscbcne < 4; uzvkrgscbcne++) {
yiptehbsczhk = vpxwfpopdveh->data[wohhjvtfkund] & picxegsrhkul[uzvkrgscbcne];
if ((yiptehbsczhk & 0xaa) == 0) { if ((yiptehbsczhk & 0x55) == 0) { bymymfzfytqi.data[vvqkgsexeirj/8] &= ~jzcdxmdrohri[vvqkgsexeirj%8];
} else { bymymfzfytqi.data[vvqkgsexeirj/8] |= jzcdxmdrohri[vvqkgsexeirj%8];
} vvqkgsexeirj++;
} } } else if (uiwmbgnbvgpr&0x40) { bymymfzfytqi.data[wohhjvtfkund] = ~vpxwfpopdveh->data[wohhjvtfkund];
} else { bymymfzfytqi.data[wohhjvtfkund] = vpxwfpopdveh->data[wohhjvtfkund];
} } uiumsbpihqax(hxzmznxdkbkc, (bc7215DataVarPkt_t*)&bymymfzfytqi);
} static void uiumsbpihqax(const struct gpbqxitaiizd* hxzmznxdkbkc, bc7215DataVarPkt_t* vpxwfpopdveh) { tkkyhdxekifj(qaecoxiakqno, vpxwfpopdveh, hxzmznxdkbkc);
if (hxzmznxdkbkc->spec.eyfkypwirzrg) { oyvkixyldkse(hxzmznxdkbkc);
} if (hxzmznxdkbkc->spec.tvmjtomrdnhm && !hxzmznxdkbkc->spec.hwzszqauakcw) { yxbwbukfxifv(hxzmznxdkbkc);
} } static void zstezjgodril(const struct gpbqxitaiizd* hxzmznxdkbkc) { uint8_t ntylrpbzdrae, wohhjvtfkund;
uint8_t fpsmitbuaqct;
uint8_t kddzikqenapu;
for (ntylrpbzdrae=0; ntylrpbzdrae<4; ntylrpbzdrae++)
{ kddzikqenapu = (hxzmznxdkbkc->aevxhrsgdbyw[ntylrpbzdrae]+7)/8;
for (wohhjvtfkund=0; wohhjvtfkund<kddzikqenapu; wohhjvtfkund++)
{ fpsmitbuaqct = qaecoxiakqno[ntylrpbzdrae][wohhjvtfkund];
if (hxzmznxdkbkc->spec.tvmjtomrdnhm && !hxzmznxdkbkc->spec.hwzszqauakcw) { fpsmitbuaqct = ngjjwymkotrg(fpsmitbuaqct);
} if (hxzmznxdkbkc->spec.eyfkypwirzrg) { fpsmitbuaqct = fsdssprrrxul(fpsmitbuaqct);
} if (vdkwwpizmwiw & 0x40) { fpsmitbuaqct = ~fpsmitbuaqct;
} tlcqethmndyr[ntylrpbzdrae][wohhjvtfkund] = fpsmitbuaqct;
} } } static void ymhmoqgzdhxz(const struct hydvnyvlqvbd* dfmcnuofogss) { uint8_t kafkqcjutjwj;
uint8_t cmzquequdqnx;
uint8_t rziichzxxsgx;
uint8_t tqyuoskiftop;
tqyuoskiftop = dfmcnuofogss->tqyuoskiftop&0x03;
kafkqcjutjwj = qaecoxiakqno[tqyuoskiftop][dfmcnuofogss->vzqhvprlrfjk];
cmzquequdqnx = (smxsfqhkzdsx[dfmcnuofogss->rrpbvlfhqqqb]&dfmcnuofogss->subgyfrmfvfm)<<dfmcnuofogss->yvofwnzsaryf;
rziichzxxsgx = ytomqlzpvxsh[dfmcnuofogss->uzeqpjupwhmw.uzeqpjupwhmw](kafkqcjutjwj, cmzquequdqnx);
kafkqcjutjwj = (kafkqcjutjwj&(~dfmcnuofogss->gnxqscpvlkfw)) | (rziichzxxsgx&dfmcnuofogss->gnxqscpvlkfw);
qaecoxiakqno[tqyuoskiftop][dfmcnuofogss->vzqhvprlrfjk] = kafkqcjutjwj;
} static void zbekytoukoab(void) { vsauocaxckoy = qjvstfqhzogz;
jqyeyoxnkgrm = prldlpdyrzae;
} static void vfmnhwdwrvuf(void) { qjvstfqhzogz = vsauocaxckoy;
prldlpdyrzae = jqyeyoxnkgrm;
} static bool nfuqjqxobnqu(uint16_t xhazxgizqggy) { jxdluxfodxlj = cnwdpipbbuwu[xhazxgizqggy];
altProtocolUsing = false;
if (((vdkwwpizmwiw&0xbf) == jxdluxfodxlj->signature) && (prldlpdyrzae.bitLen == jxdluxfodxlj->bitLen)) { xppwyewwolze(jxdluxfodxlj, vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&prldlpdyrzae);
if (vuawcztbcsbf(jxdluxfodxlj)) { if (jxdluxfodxlj->kgcvzngryhap.lwvakrvplqdt&0x20) { ((const struct ojyxxaaevkqk*)jxdluxfodxlj->kgcvzngryhap.npuwofjjnfva)->hxzmznxdkbkc.qinxsyloyejd.cikjcvnkgdnt(NULL, NULL);
} return true;
} } return false;
} static bool wovbozguvhco(bc7215FormatPkt_t* format, uint16_t bnmrfpetoybu, uint8_t umbdaltpywvp, uint8_t nuqhgngzwici) { uint8_t ntylrpbzdrae, wohhjvtfkund, oldSpecial, newSpecial, oldTypeCnt;
uint16_t dugphlqjgyyk;
uint8_t*  ifqccwfduzof;
uint8_t*  qjjihfoqlqvv;
ifqccwfduzof = (uint8_t*)format;
oldSpecial = (*ifqccwfduzof&0x07)^0x05;
newSpecial =  oldSpecial*(umbdaltpywvp+1)+umbdaltpywvp;
if (newSpecial >8) { return false;
} *ifqccwfduzof = (*ifqccwfduzof&0xf8)+(newSpecial^5);
ifqccwfduzof += 9;
oldTypeCnt = *ifqccwfduzof;
*ifqccwfduzof++ = (((oldTypeCnt^0x1d)&0x7f)+1)^29;
*ifqccwfduzof = (*ifqccwfduzof&0x80)+(newSpecial^29);
ifqccwfduzof++;
if ((oldTypeCnt&0x7f) == 29) { *ifqccwfduzof++ = ((*((uint8_t*)format+1)^29)/2)^29;
*ifqccwfduzof = 226;
} else { ifqccwfduzof = ifqccwfduzof+2*(oldTypeCnt^29);
*(ifqccwfduzof++) = ((*((uint8_t*)format+1)^29)+1)/2;
*ifqccwfduzof = 0xff;
} qjjihfoqlqvv = (uint8_t*)format+17;
ifqccwfduzof = qjjihfoqlqvv+oldSpecial*2;
for (wohhjvtfkund=0; wohhjvtfkund<umbdaltpywvp; wohhjvtfkund++)
{ dugphlqjgyyk = ((bnmrfpetoybu*(wohhjvtfkund+1)) |((oldTypeCnt^0x1d)<<12))|0x8000;
*ifqccwfduzof++ = dugphlqjgyyk&0xff;
*ifqccwfduzof++ = dugphlqjgyyk>>8;
for (ntylrpbzdrae=0; ntylrpbzdrae<oldSpecial; ntylrpbzdrae++)
{ newSpecial = *(qjjihfoqlqvv+ntylrpbzdrae*2);
oldTypeCnt = *(qjjihfoqlqvv+ntylrpbzdrae*2+1);
dugphlqjgyyk = (bnmrfpetoybu*(wohhjvtfkund+1)+ (newSpecial | ((oldTypeCnt<<8)&0x0fff))) | ((oldTypeCnt<<8)&0xf000);
*ifqccwfduzof++ = dugphlqjgyyk&0xff;
*ifqccwfduzof++ = dugphlqjgyyk>>8;
} } if (newSpecial < 8) { *((uint8_t*)format+31) = nuqhgngzwici;
} return true;
} static void eosqtleleitw(const struct gpbqxitaiizd* hxzmznxdkbkc) { const struct rsvujpsrigrz*  dopurjebwwee;
altProtocolUsing = true;
zbekytoukoab();
dopurjebwwee = (const struct rsvujpsrigrz*)hxzmznxdkbkc->dhpgcjvwtiqx->set.rtwwplmlhifa;
wovbozguvhco(&qjvstfqhzogz, prldlpdyrzae.bitLen, dopurjebwwee->umbdaltpywvp, dopurjebwwee->nuqhgngzwici);
dapkfliuefws(dopurjebwwee->hxzmznxdkbkc, rqfnuxkfmrjn);
zstezjgodril(dopurjebwwee->hxzmznxdkbkc);
tmvqpybvzasi(dopurjebwwee->hxzmznxdkbkc);
jxdluxfodxlj = dopurjebwwee->hxzmznxdkbkc;
vdkwwpizmwiw = qjvstfqhzogz.signature.bits.sig;
bc7215_ac_replace_base(vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&ywvlglmedvkw);
} static bool nsnyhgkvpncc(uint16_t lmcaackmkrdy, uint8_t rrpbvlfhqqqb, uint8_t komeyrxzqnuf) { if (komeyrxzqnuf == 0) { komeyrxzqnuf = 60;
} if (komeyrxzqnuf < 37) { komeyrxzqnuf = 37;
} if (komeyrxzqnuf > 72) { komeyrxzqnuf = 72;
} komeyrxzqnuf = (komeyrxzqnuf*7)&0xff;
if (rrpbvlfhqqqb > 1) { if (!wovbozguvhco(&qjvstfqhzogz, lmcaackmkrdy, rrpbvlfhqqqb-1, komeyrxzqnuf)) { return false;
} } return true;
} static bool yzcoenevrwfk(uint8_t hdfsvfrtpjnk, const bc7215CombinedMsg_t vzapmbayxltb[]) { uint8_t ntylrpbzdrae, kddzikqenapu;
uint16_t ujdbqaolzcnb;
struct gpbqxitaiizd yjvxktwphnbw= {0};
ujdbqaolzcnb = 0;
if ((hdfsvfrtpjnk > 0) && (hdfsvfrtpjnk <= 4)) { for (ntylrpbzdrae=0; ntylrpbzdrae<4; ntylrpbzdrae++)
{ if (ntylrpbzdrae < hdfsvfrtpjnk) { yjvxktwphnbw.aevxhrsgdbyw[ntylrpbzdrae] = vzapmbayxltb[ntylrpbzdrae].body.msg.datPkt->bitLen;
ujdbqaolzcnb += yjvxktwphnbw.aevxhrsgdbyw[ntylrpbzdrae];
kddzikqenapu = (yjvxktwphnbw.aevxhrsgdbyw[ntylrpbzdrae]+7)/8;
memcpy(tlcqethmndyr[ntylrpbzdrae], vzapmbayxltb[ntylrpbzdrae].body.msg.datPkt->data, kddzikqenapu);
} else { yjvxktwphnbw.aevxhrsgdbyw[ntylrpbzdrae] = 0;
} } yjvxktwphnbw.bitLen = ujdbqaolzcnb;
tmvqpybvzasi(&yjvxktwphnbw);
return true;
} return false;
} static void nxjcjvdruonz(const struct gpbqxitaiizd* hxzmznxdkbkc) { const rbpeihvtnuyd* wgtbziimfabd;
if (hxzmznxdkbkc->qyillnqmaztz.lwvakrvplqdt&0x80) { wgtbziimfabd = ((const struct rsvujpsrigrz*)hxzmznxdkbkc->dhpgcjvwtiqx->set.rtwwplmlhifa)->yzanflvvuasy;
} else { wgtbziimfabd = hxzmznxdkbkc->dhpgcjvwtiqx->set.rtwwplmlhifa;
} while ((wgtbziimfabd != NULL) && (wgtbziimfabd->kgwutrfbqzlk != NULL)) { if ((aptgxbmrneqq[wgtbziimfabd->pmnvkelkphhj] >= 0) && (aptgxbmrneqq[wgtbziimfabd->pmnvkelkphhj] < 0x0f)) { qaecoxiakqno[wgtbziimfabd->lwvakrvplqdt][wgtbziimfabd->ecxwwscrklsl&0x3f] = (qaecoxiakqno[wgtbziimfabd->lwvakrvplqdt][wgtbziimfabd->ecxwwscrklsl&0x3f]&(~wgtbziimfabd->cglziorkljus)) | (wgtbziimfabd->kgwutrfbqzlk[aptgxbmrneqq[wgtbziimfabd->pmnvkelkphhj]]&wgtbziimfabd->cglziorkljus);
} wgtbziimfabd++;
} } static const bc7215DataVarPkt_t* mvlsxqjbgcmg(uint8_t dcswboinzjto) { xppwyewwolze(jxdluxfodxlj, vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&prldlpdyrzae);
if ((dcswboinzjto == 4) || jxdluxfodxlj->spec.jooqmrimufrf) { rrgvexenfoby(&jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.lnrpcoyamxnd, rqfnuxkfmrjn);
rrgvexenfoby(&jxdluxfodxlj->qinxsyloyejd.gecmoisvuikh.aqpwroyoznxu, rqfnuxkfmrjn);
} smxsfqhkzdsx[0] = 0;
smxsfqhkzdsx[1] = 0;
smxsfqhkzdsx[2] = 0;
smxsfqhkzdsx[3] = slchrdesbcgd(&jxdluxfodxlj->qyillnqmaztz, dcswboinzjto, rqfnuxkfmrjn);
aptgxbmrneqq[0] = -1;
aptgxbmrneqq[1] = -1;
aptgxbmrneqq[2] = -1;
aptgxbmrneqq[3] = dcswboinzjto;
nxjcjvdruonz(jxdluxfodxlj);
dapkfliuefws(jxdluxfodxlj, rqfnuxkfmrjn);
zstezjgodril(jxdluxfodxlj);
tmvqpybvzasi(jxdluxfodxlj);
xppwyewwolze(jxdluxfodxlj, vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&prldlpdyrzae);
if (altProtocolUsing) { pmztwdjerbgj.body.msg.fmt = &qjvstfqhzogz;
pmztwdjerbgj.body.msg.datPkt = (bc7215DataVarPkt_t*)&ywvlglmedvkw;
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} else { return (const bc7215DataVarPkt_t*)&ywvlglmedvkw;
} } static void zxzhyjytwodx(uint8_t dyjqlrknyzqj, uint8_t rrxkxmopfrrm) { uint8_t jtytroghrsgy;
uint8_t ljssgvuxuzae;
uint8_t npuwofjjnfva;
jtytroghrsgy = dyjqlrknyzqj >> 4 ;
ljssgvuxuzae = rrxkxmopfrrm >> 4 ;
npuwofjjnfva = rrxkxmopfrrm&0x0f;
if (ljssgvuxuzae & 0xFC) { ljssgvuxuzae &= 0x03;
npuwofjjnfva += 0x10;
} if ((jtytroghrsgy < 4) && (ljssgvuxuzae < 4)) { if (aptgxbmrneqq[jtytroghrsgy] == (dyjqlrknyzqj&0x0f)) { aptgxbmrneqq[ljssgvuxuzae] = npuwofjjnfva;
} } else if ((jtytroghrsgy < 8) && (ljssgvuxuzae < 4)) { jtytroghrsgy -= 4;
if (aptgxbmrneqq[jtytroghrsgy] < (dyjqlrknyzqj&0x0f)) { aptgxbmrneqq[ljssgvuxuzae] = npuwofjjnfva;
} } else if ((jtytroghrsgy < 12) && (ljssgvuxuzae < 4)) { jtytroghrsgy -= 8;
if (aptgxbmrneqq[jtytroghrsgy] > (dyjqlrknyzqj&0x0f)) { aptgxbmrneqq[ljssgvuxuzae] = npuwofjjnfva;
} } } static bool qodraidchjty(uint8_t uiwmbgnbvgpr, const bc7215DataVarPkt_t* dataPktCool25C) { uint16_t ntylrpbzdrae;
uint16_t kddzikqenapu;
const bc7215FormatPkt_t* fmt = NULL;
jxdluxfodxlj = NULL;
formatLoaded = false;
secFmtLoaded = false;
if (dataPktCool25C->bitLen == 0) { fmt = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.fmt;
if (fmt != NULL) { qjvstfqhzogz = *fmt;
formatLoaded = true;
} dataPktCool25C = ((const bc7215CombinedMsg_t*)dataPktCool25C)->body.msg.datPkt;
if ((fmt == NULL) || (dataPktCool25C == NULL)) { return false;
} } vdkwwpizmwiw = uiwmbgnbvgpr;
prldlpdyrzae.bitLen = dataPktCool25C->bitLen;
kddzikqenapu = (prldlpdyrzae.bitLen+7)/8;
memcpy(prldlpdyrzae.data, dataPktCool25C->data, kddzikqenapu);
hojowlpholah = -1;
for (ntylrpbzdrae=0; ntylrpbzdrae<elwxztlbomnj; ntylrpbzdrae++) {
if (nfuqjqxobnqu(ntylrpbzdrae)) { hojowlpholah = ntylrpbzdrae;
pnum=ntylrpbzdrae;
return true;
} } return false;
} static bool ckhydjzdnxvl(uint8_t hdfsvfrtpjnk, const bc7215CombinedMsg_t vzapmbayxltb[], uint8_t nlhdelyxphtt) { jxdluxfodxlj = NULL;
if (vzapmbayxltb[0].body.msg.fmt != NULL) { qjvstfqhzogz = *vzapmbayxltb[0].body.msg.fmt;
if (yzcoenevrwfk(hdfsvfrtpjnk, vzapmbayxltb) && nsnyhgkvpncc(vzapmbayxltb[0].body.msg.datPkt->bitLen, hdfsvfrtpjnk, nlhdelyxphtt)) { return qodraidchjty(qjvstfqhzogz.signature.bits.sig, (const bc7215DataVarPkt_t*)&ywvlglmedvkw);
} } return false;
} static const bc7215DataVarPkt_t* fnoeghlokbon(int8_t gzqhxdxdrwge, int8_t gzvsqgozhzak, int8_t oiartonrdyyd, int8_t dopurjebwwee) { bool tmpProtocolUsing;
uint8_t nhngcbmdhkke;
uint8_t zpdkjsjplzxv;
const struct gpbqxitaiizd* qikpljqbogyu;
tmpProtocolUsing = false;
qikpljqbogyu = jxdluxfodxlj;
if ((dopurjebwwee == KEY_MODE) && (jxdluxfodxlj->kgcvzngryhap.lwvakrvplqdt&0x20)) { jxdluxfodxlj = &((const struct ojyxxaaevkqk*)jxdluxfodxlj->kgcvzngryhap.npuwofjjnfva)->hxzmznxdkbkc;
tmpProtocolUsing = true;
} else if (((dopurjebwwee == KEY_PLUS) || (dopurjebwwee == KEY_MINUS)) && (jxdluxfodxlj->mmzlyxxngkvo.lwvakrvplqdt&0x20)) { jxdluxfodxlj = &((const struct ojyxxaaevkqk*)jxdluxfodxlj->mmzlyxxngkvo.npuwofjjnfva)->hxzmznxdkbkc;
tmpProtocolUsing = true;
} else if ((dopurjebwwee == KEY_FAN) && (jxdluxfodxlj->symhfchmtzss.lwvakrvplqdt&0x20)) { jxdluxfodxlj = &((const struct ojyxxaaevkqk*)jxdluxfodxlj->symhfchmtzss.npuwofjjnfva)->hxzmznxdkbkc;
tmpProtocolUsing = true;
} if (tmpProtocolUsing) { jqyeyoxnkgrm = prldlpdyrzae;
if (!bc7215_ac_replace_base(bqmuktkksqrn, (const bc7215DataVarPkt_t*)&hbrgftpnwiaa)) { return NULL;
} } aptgxbmrneqq[0] = gzqhxdxdrwge;
aptgxbmrneqq[1] = gzvsqgozhzak;
aptgxbmrneqq[2] = oiartonrdyyd;
aptgxbmrneqq[3] = dopurjebwwee;
if (jxdluxfodxlj != NULL) { if (!jxdluxfodxlj->spec.ztbdlqclufjr) { nhngcbmdhkke = jxdluxfodxlj->dhpgcjvwtiqx->set.gvceqldfsjbh;
zpdkjsjplzxv = jxdluxfodxlj->dhpgcjvwtiqx->set.svwxyronflvt;
zxzhyjytwodx(nhngcbmdhkke, zpdkjsjplzxv);
nhngcbmdhkke = jxdluxfodxlj->dhpgcjvwtiqx->set.hplcrxatdrct;
zpdkjsjplzxv = jxdluxfodxlj->dhpgcjvwtiqx->set.lhgglrlmdmxw;
zxzhyjytwodx(nhngcbmdhkke, zpdkjsjplzxv);
nhngcbmdhkke = jxdluxfodxlj->dhpgcjvwtiqx->set.lixjnvkxpnfb;
zpdkjsjplzxv = jxdluxfodxlj->dhpgcjvwtiqx->set.uifcjtjakghm;
zxzhyjytwodx(nhngcbmdhkke, zpdkjsjplzxv);
} smxsfqhkzdsx[0] = 0;
smxsfqhkzdsx[1] = 0;
smxsfqhkzdsx[2] = 0;
smxsfqhkzdsx[3] = 0;
if (aptgxbmrneqq[0] >= 0) { smxsfqhkzdsx[0] = slchrdesbcgd(&jxdluxfodxlj->mmzlyxxngkvo, aptgxbmrneqq[0], rqfnuxkfmrjn);
} if ((aptgxbmrneqq[1] >= 0) && (aptgxbmrneqq[1]<0x0f)) { smxsfqhkzdsx[1] = slchrdesbcgd(&jxdluxfodxlj->kgcvzngryhap, aptgxbmrneqq[1], rqfnuxkfmrjn);
if (jxdluxfodxlj->kgcvzngryhap.lwvakrvplqdt & 0x80) { aptgxbmrneqq[3] = aptgxbmrneqq[1];
} } if ((aptgxbmrneqq[2] >= 0) && (aptgxbmrneqq[2] < 0x0f)) { smxsfqhkzdsx[2] = slchrdesbcgd(&jxdluxfodxlj->symhfchmtzss, aptgxbmrneqq[2], rqfnuxkfmrjn);
if (jxdluxfodxlj->symhfchmtzss.lwvakrvplqdt & 0x80) { aptgxbmrneqq[3] = aptgxbmrneqq[2];
} } if ((aptgxbmrneqq[3] >= 0) && (aptgxbmrneqq[3]<0x0f)) { smxsfqhkzdsx[3] = slchrdesbcgd(&jxdluxfodxlj->qyillnqmaztz, aptgxbmrneqq[3], rqfnuxkfmrjn);
} if (jxdluxfodxlj->dhpgcjvwtiqx->set.rtwwplmlhifa != NULL) { nxjcjvdruonz(jxdluxfodxlj);
} dapkfliuefws(jxdluxfodxlj, rqfnuxkfmrjn);
zstezjgodril(jxdluxfodxlj);
tmvqpybvzasi(jxdluxfodxlj);
if (tmpProtocolUsing) { jxdluxfodxlj = qikpljqbogyu;
if (!bc7215_ac_replace_base(vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&jqyeyoxnkgrm)) { return NULL;
} if (secFmtLoaded) { pmztwdjerbgj.body.msg.fmt = &frqztynarjsr;
pmztwdjerbgj.body.msg.datPkt = (bc7215DataVarPkt_t*)&ywvlglmedvkw;
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} } if (altProtocolUsing) { pmztwdjerbgj.body.msg.fmt = &qjvstfqhzogz;
pmztwdjerbgj.body.msg.datPkt = (bc7215DataVarPkt_t*)&ywvlglmedvkw;
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} else { return (const bc7215DataVarPkt_t*)&ywvlglmedvkw;
} } else { return  NULL;
} } const char* bc7215_ac_get_ver(void) { return VERSION;
} bool bc7215_ac_init(uint8_t uiwmbgnbvgpr, const bc7215DataVarPkt_t* dataPktCool25C) { fahrenheitInit = false;
return qodraidchjty(uiwmbgnbvgpr, dataPktCool25C);
} bool bc7215_ac_init_f(uint8_t uiwmbgnbvgpr, const bc7215DataVarPkt_t* mfvpbdhcbtvi) { fahrenheitInit = true;
return qodraidchjty(uiwmbgnbvgpr, mfvpbdhcbtvi);
} bool bc7215_ac_init2(uint8_t hdfsvfrtpjnk, const bc7215CombinedMsg_t vzapmbayxltb[], uint8_t nlhdelyxphtt) { fahrenheitInit = false;
return ckhydjzdnxvl(hdfsvfrtpjnk, vzapmbayxltb, nlhdelyxphtt);
} bool bc7215_ac_init2_f(uint8_t hdfsvfrtpjnk, const bc7215CombinedMsg_t vzapmbayxltb[], uint8_t nlhdelyxphtt) { fahrenheitInit = true;
return ckhydjzdnxvl(hdfsvfrtpjnk, vzapmbayxltb, nlhdelyxphtt);
} bool bc7215_ac_find_next(void) { uint16_t ntylrpbzdrae;
if (hojowlpholah >= 0) { if (altProtocolUsing) { vfmnhwdwrvuf();
altProtocolUsing = false;
} else if (((jxdluxfodxlj->qyillnqmaztz.lwvakrvplqdt&0xf0) == 0x80) && formatLoaded) { eosqtleleitw(jxdluxfodxlj);
return true;
} else if ((jxdluxfodxlj->qyillnqmaztz.lwvakrvplqdt&0xf0) == 0xe0) { altProtocolUsing = true;
return true;
} for (ntylrpbzdrae=hojowlpholah+1; ntylrpbzdrae<elwxztlbomnj; ntylrpbzdrae++)
{ if (nfuqjqxobnqu(ntylrpbzdrae)) { hojowlpholah = ntylrpbzdrae;
pnum=ntylrpbzdrae;
return true;
} } } hojowlpholah = -1;
jxdluxfodxlj = NULL;
return false;
} const bc7215DataVarPkt_t* bc7215_ac_set(int8_t nicibroattym, int8_t gzvsqgozhzak, int8_t oiartonrdyyd, int8_t dopurjebwwee) { if (nicibroattym > 14) { nicibroattym = -1;
} if (gzvsqgozhzak > MODE_FAN) { gzvsqgozhzak = -1;
} if (oiartonrdyyd > FAN_HIGH) { oiartonrdyyd = -1;
} if (dopurjebwwee > KEY_FAN) { dopurjebwwee = -1;
} return fnoeghlokbon(nicibroattym, gzvsqgozhzak, oiartonrdyyd, dopurjebwwee);
} const bc7215DataVarPkt_t* bc7215_ac_set_f(int8_t qsxxgkmcmmgp, int8_t gzvsqgozhzak, int8_t oiartonrdyyd, int8_t dopurjebwwee) { uint8_t	nicibroattym;
if (gzvsqgozhzak > MODE_FAN) { gzvsqgozhzak = -1;
} if (oiartonrdyyd > FAN_HIGH) { oiartonrdyyd = -1;
} if (dopurjebwwee > KEY_FAN) { dopurjebwwee = -1;
} if ((qsxxgkmcmmgp < 0) || (qsxxgkmcmmgp > 28)) { nicibroattym = -1;
} else { if (jxdluxfodxlj->dbooiubuftmj != NULL) { nicibroattym = jxdluxfodxlj->dbooiubuftmj->nrzmlxiqnvjp[qsxxgkmcmmgp];
slchrdesbcgd(&jxdluxfodxlj->dbooiubuftmj->kmdfjjawpchr, qsxxgkmcmmgp, rqfnuxkfmrjn);
} else { nicibroattym = xiomrpyxzinu.nrzmlxiqnvjp[qsxxgkmcmmgp];
} } return fnoeghlokbon(nicibroattym, gzvsqgozhzak, oiartonrdyyd, dopurjebwwee);
} const bc7215DataVarPkt_t* bc7215_ac_on(void) { uint16_t ovaxilzdyuvm;
const uint8_t*	nfpybbdkwjbw;
if (hojowlpholah >= 0) { if (jxdluxfodxlj->spec.wibvdpdgotxx) { nfpybbdkwjbw = (const uint8_t*)jxdluxfodxlj->qinxsyloyejd.lztusevbiwbk;
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
if (bymymfzfytqi.bitLen != 0) { ovaxilzdyuvm = (bymymfzfytqi.bitLen+7)/8+2;
nfpybbdkwjbw = nfpybbdkwjbw+ovaxilzdyuvm;
if ((*nfpybbdkwjbw != 0) || (*(nfpybbdkwjbw+1) != 0)) { bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
if (altProtocolUsing) { pmztwdjerbgj.bitLen = 0;
pmztwdjerbgj.body.msg.fmt = &qjvstfqhzogz;
pmztwdjerbgj.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} else { return (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
} } } else { nfpybbdkwjbw += 2;
memcpy(&zjnjccznsglv, nfpybbdkwjbw, 33);
nfpybbdkwjbw += 33;
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
ovaxilzdyuvm = (bymymfzfytqi.bitLen+7)/8+2;
nfpybbdkwjbw += ovaxilzdyuvm;
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
if (bymymfzfytqi.bitLen != 0) { memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
pmztwdjerbgj.bitLen = 0;
pmztwdjerbgj.body.msg.fmt = &zjnjccznsglv;
pmztwdjerbgj.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} } } else if (jxdluxfodxlj->spec.jooqmrimufrf || (!((jxdluxfodxlj->mmzlyxxngkvo.lwvakrvplqdt | jxdluxfodxlj->kgcvzngryhap.lwvakrvplqdt | jxdluxfodxlj->symhfchmtzss.lwvakrvplqdt)&0x80) && (jxdluxfodxlj->qyillnqmaztz.npuwofjjnfva != NULL))) { return mvlsxqjbgcmg(5);
} } return NULL;
} const bc7215DataVarPkt_t* bc7215_ac_off(void) { const uint8_t*	nfpybbdkwjbw;
if (hojowlpholah >= 0) { if (!jxdluxfodxlj->spec.wibvdpdgotxx) { return mvlsxqjbgcmg(4);
} else { nfpybbdkwjbw = (const uint8_t*)jxdluxfodxlj->qinxsyloyejd.lztusevbiwbk;
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
if (bymymfzfytqi.bitLen != 0) { memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
if (altProtocolUsing) { pmztwdjerbgj.bitLen = 0;
pmztwdjerbgj.body.msg.fmt = &qjvstfqhzogz;
pmztwdjerbgj.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} else { return (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
} } else { nfpybbdkwjbw += 2;
memcpy(&zjnjccznsglv, nfpybbdkwjbw, 33);
nfpybbdkwjbw += 33;
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
if (bymymfzfytqi.bitLen != 0) { pmztwdjerbgj.bitLen = 0;
pmztwdjerbgj.body.msg.fmt = &zjnjccznsglv;
pmztwdjerbgj.body.msg.datPkt = (const bc7215DataVarPkt_t*)(&bymymfzfytqi);
return (const bc7215DataVarPkt_t*)&pmztwdjerbgj;
} } } } return NULL;
} uint8_t bc7215_ac_predefined_cnt(void) { return ijtbuxyjlwcl;
} const bc7215DataVarPkt_t* bc7215_ac_predefined_data(uint8_t fmtejjmercwt) { const uint8_t* nfpybbdkwjbw;
if (fmtejjmercwt < ijtbuxyjlwcl) { nfpybbdkwjbw = (const uint8_t*)epyuhudmrosj[fmtejjmercwt];
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&bymymfzfytqi;
} else { return NULL;
} } const bc7215DataVarPkt_t* bc7215_ac_predefined_data_f(uint8_t fmtejjmercwt) { const uint8_t* nfpybbdkwjbw;
if (fmtejjmercwt < ijtbuxyjlwcl) { nfpybbdkwjbw = (const uint8_t*)ooaftaidqqgg[fmtejjmercwt];
bymymfzfytqi.bitLen = ((*(nfpybbdkwjbw+1))<<8)+*nfpybbdkwjbw;
memcpy(&bymymfzfytqi.data, nfpybbdkwjbw+2, (bymymfzfytqi.bitLen+7)/8);
return (const bc7215DataVarPkt_t*)&bymymfzfytqi;
} else { return NULL;
} } const bc7215FormatPkt_t* bc7215_ac_predefined_fmt(uint8_t fmtejjmercwt) { if (fmtejjmercwt < ijtbuxyjlwcl) { memcpy(&zjnjccznsglv, ((const uint8_t*)&qnjwemvunutx)+33*fmtejjmercwt, 33);
return &zjnjccznsglv;
} else { return NULL;
} } const char* bc7215_ac_predefined_name(uint8_t fmtejjmercwt) { if (fmtejjmercwt < ijtbuxyjlwcl) { return PREDEFINDED_NAMES[fmtejjmercwt];
} else { return "";
} } uint8_t bc7215_ac_need_extra_sample(void) { uint8_t rziichzxxsgx;
rziichzxxsgx = 0;
if (jxdluxfodxlj != NULL) { if (jxdluxfodxlj->mmzlyxxngkvo.lwvakrvplqdt&0x20) { rziichzxxsgx = 1;
} if (jxdluxfodxlj->kgcvzngryhap.lwvakrvplqdt&0x20) { rziichzxxsgx = 2;
} if (jxdluxfodxlj->symhfchmtzss.lwvakrvplqdt&0x20) { rziichzxxsgx = 3;
} if (((jxdluxfodxlj->qyillnqmaztz.lwvakrvplqdt&0xf0) == 0xc0) ||(altProtocolUsing && ((jxdluxfodxlj->qyillnqmaztz.lwvakrvplqdt&0xf0) == 0xe0))) { rziichzxxsgx = 4;
} } return rziichzxxsgx;
} bool bc7215_ac_save_2nd_base(uint8_t uiwmbgnbvgpr, const bc7215CombinedMsg_t* message) { uint8_t kddzikqenapu;
if (!(uiwmbgnbvgpr&0x80) && (message->body.msg.fmt->signature.bits.sig == (uiwmbgnbvgpr&0x3f))) { kddzikqenapu = (message->body.msg.datPkt->bitLen+7)/8;
if (kddzikqenapu <= BC7215_MAX_RX_DATA_SIZE) { frqztynarjsr = *message->body.msg.fmt;
secFmtLoaded = true;
bqmuktkksqrn = uiwmbgnbvgpr;
hbrgftpnwiaa.bitLen = message->body.msg.datPkt->bitLen;
memcpy(hbrgftpnwiaa.data, message->body.msg.datPkt->data, kddzikqenapu);
return true;
} } return false;
} bc7215CombinedMsg_t bc7215_ac_get_2nd_base(void) { bc7215CombinedMsg_t msudopczmuwu;
msudopczmuwu.bitLen = 0;
msudopczmuwu.body.msg.datPkt = (bc7215DataVarPkt_t*)&hbrgftpnwiaa;
msudopczmuwu.body.msg.fmt = &frqztynarjsr;
return msudopczmuwu;
} bool bc7215_ac_replace_base(uint8_t uiwmbgnbvgpr, const bc7215DataVarPkt_t* iueutsbzmtfr) { uint8_t kddzikqenapu;
if ((jxdluxfodxlj != NULL) && (iueutsbzmtfr->bitLen <= BC7215_MAX_RX_DATA_SIZE*8)) { if (iueutsbzmtfr->bitLen != 0) { vdkwwpizmwiw = uiwmbgnbvgpr;
kddzikqenapu = (iueutsbzmtfr->bitLen+7)/8;
memcpy(prldlpdyrzae.data, iueutsbzmtfr->data, kddzikqenapu);
prldlpdyrzae.bitLen = iueutsbzmtfr->bitLen;
} else { yzcoenevrwfk(uiwmbgnbvgpr, (const bc7215CombinedMsg_t*) iueutsbzmtfr);
vdkwwpizmwiw = qjvstfqhzogz.signature.bits.sig;
prldlpdyrzae = ywvlglmedvkw;
} xppwyewwolze(jxdluxfodxlj, vdkwwpizmwiw, (const bc7215DataVarPkt_t*)&prldlpdyrzae);
return true;
} else { return false;
} } const bc7215FormatPkt_t* bc7215_ac_get_base_fmt(void) { return &qjvstfqhzogz;
} const bc7215DataVarPkt_t* bc7215_ac_get_base_data(void) { return (bc7215DataVarPkt_t*)&prldlpdyrzae;
} bool bc7215_ac_parse(int8_t* gzqhxdxdrwge, int8_t* gzvsqgozhzak, int8_t* oiartonrdyyd, int8_t* nupzgchqhaya) { bool rziichzxxsgx;
rziichzxxsgx = dapkfliuefws(jxdluxfodxlj, jxusjozdkpwz);
*gzqhxdxdrwge = -1;
*gzvsqgozhzak = -1;
*oiartonrdyyd = -1;
*nupzgchqhaya = -1;
if (rziichzxxsgx) { *gzqhxdxdrwge = moaiqlamhzrj(&jxdluxfodxlj->mmzlyxxngkvo, 15);
*gzvsqgozhzak = moaiqlamhzrj(&jxdluxfodxlj->kgcvzngryhap, 5);
*oiartonrdyyd = moaiqlamhzrj(&jxdluxfodxlj->symhfchmtzss, 4);
*nupzgchqhaya = kpqlkeowmbcu(jxdluxfodxlj);
} return rziichzxxsgx;
} bool bc7215_ac_parse_f(int8_t* qsxxgkmcmmgp, int8_t* gzvsqgozhzak, int8_t* oiartonrdyyd, int8_t* nupzgchqhaya) { bool rziichzxxsgx;
rziichzxxsgx = bc7215_ac_parse(qsxxgkmcmmgp, gzvsqgozhzak, oiartonrdyyd, nupzgchqhaya);
if (rziichzxxsgx && (*qsxxgkmcmmgp >= 0)) { if (jxdluxfodxlj->dbooiubuftmj != NULL) { *qsxxgkmcmmgp = xpegizsqfutt(jxdluxfodxlj->dbooiubuftmj, *qsxxgkmcmmgp);
} else { *qsxxgkmcmmgp = xpegizsqfutt(&xiomrpyxzinu, *qsxxgkmcmmgp);
} } return rziichzxxsgx;
}